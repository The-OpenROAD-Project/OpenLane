* NGSPICE file created from reg_file.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_4 abstract view
.subckt sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_4 abstract view
.subckt sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

.subckt reg_file VGND VPWR clk_i port1_data_o[0] port1_data_o[10] port1_data_o[11]
+ port1_data_o[12] port1_data_o[13] port1_data_o[14] port1_data_o[15] port1_data_o[16]
+ port1_data_o[17] port1_data_o[18] port1_data_o[19] port1_data_o[1] port1_data_o[20]
+ port1_data_o[21] port1_data_o[22] port1_data_o[23] port1_data_o[24] port1_data_o[25]
+ port1_data_o[26] port1_data_o[27] port1_data_o[28] port1_data_o[29] port1_data_o[2]
+ port1_data_o[30] port1_data_o[31] port1_data_o[3] port1_data_o[4] port1_data_o[5]
+ port1_data_o[6] port1_data_o[7] port1_data_o[8] port1_data_o[9] port1_reg_i[0] port1_reg_i[1]
+ port1_reg_i[2] port1_reg_i[3] port1_reg_i[4] port2_data_o[0] port2_data_o[10] port2_data_o[11]
+ port2_data_o[12] port2_data_o[13] port2_data_o[14] port2_data_o[15] port2_data_o[16]
+ port2_data_o[17] port2_data_o[18] port2_data_o[19] port2_data_o[1] port2_data_o[20]
+ port2_data_o[21] port2_data_o[22] port2_data_o[23] port2_data_o[24] port2_data_o[25]
+ port2_data_o[26] port2_data_o[27] port2_data_o[28] port2_data_o[29] port2_data_o[2]
+ port2_data_o[30] port2_data_o[31] port2_data_o[3] port2_data_o[4] port2_data_o[5]
+ port2_data_o[6] port2_data_o[7] port2_data_o[8] port2_data_o[9] port2_reg_i[0] port2_reg_i[1]
+ port2_reg_i[2] port2_reg_i[3] port2_reg_i[4] wr_data_i[0] wr_data_i[10] wr_data_i[11]
+ wr_data_i[12] wr_data_i[13] wr_data_i[14] wr_data_i[15] wr_data_i[16] wr_data_i[17]
+ wr_data_i[18] wr_data_i[19] wr_data_i[1] wr_data_i[20] wr_data_i[21] wr_data_i[22]
+ wr_data_i[23] wr_data_i[24] wr_data_i[25] wr_data_i[26] wr_data_i[27] wr_data_i[28]
+ wr_data_i[29] wr_data_i[2] wr_data_i[30] wr_data_i[31] wr_data_i[3] wr_data_i[4]
+ wr_data_i[5] wr_data_i[6] wr_data_i[7] wr_data_i[8] wr_data_i[9] wr_en_i wr_reg_i[0]
+ wr_reg_i[1] wr_reg_i[2] wr_reg_i[3] wr_reg_i[4]
X_05903_ _02794_ VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__clkbuf_1
XFILLER_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09671_ net769 _01643_ VGND VGND VPWR VPWR rf\[27\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_06883_ rf\[0\]\[22\] rf\[1\]\[22\] rf\[2\]\[22\] rf\[3\]\[22\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03395_ sky130_fd_sc_hd__mux4_1
XFILLER_27_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05834_ _02758_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__clkbuf_1
X_05765_ _02074_ rf\[22\]\[20\] _02711_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__mux2_1
X_08725__752 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__inv_2
X_08231__284 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__inv_2
XFILLER_54_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07504_ _03623_ _03977_ _03986_ _03650_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__o211a_1
X_04716_ rf\[19\]\[10\] _02094_ _02154_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__mux2_1
X_05696_ _02687_ VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__clkbuf_1
X_07435_ _03603_ _03920_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__or2_1
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04647_ rf\[3\]\[11\] _02092_ _02119_ VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__mux2_1
XFILLER_50_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04578_ _02099_ VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_10_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07366_ rf\[8\]\[12\] rf\[9\]\[12\] rf\[10\]\[12\] rf\[11\]\[12\] _03646_ _03591_
+ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__mux4_1
X_07297_ rf\[0\]\[9\] rf\[1\]\[9\] rf\[2\]\[9\] rf\[3\]\[9\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03790_ sky130_fd_sc_hd__mux4_2
X_09105_ net203 _01077_ VGND VGND VPWR VPWR rf\[29\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06317_ _02096_ rf\[14\]\[9\] _02985_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__mux2_1
X_06248_ _02972_ VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__clkbuf_1
X_08470__511 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__inv_2
X_06179_ _02936_ VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__clkbuf_1
XFILLER_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09938_ net1036 _01910_ VGND VGND VPWR VPWR rf\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_08585__620 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__inv_2
XFILLER_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08091__152 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__inv_2
X_09869_ net967 _01841_ VGND VGND VPWR VPWR rf\[7\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08208__264 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__inv_2
XFILLER_115_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04490_ _04490_ VGND VGND VPWR VPWR clknet_0__04490_ sky130_fd_sc_hd__clkbuf_16
XFILLER_68_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08748__774 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__inv_2
X_10009_ net1107 _01981_ VGND VGND VPWR VPWR rf\[19\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_05550_ _02611_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__clkbuf_1
X_05481_ _02575_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__clkbuf_1
X_07220_ rf\[12\]\[5\] rf\[13\]\[5\] rf\[14\]\[5\] rf\[15\]\[5\] _03599_ _03600_ VGND
+ VGND VPWR VPWR _03717_ sky130_fd_sc_hd__mux4_1
X_07151_ rf\[0\]\[2\] rf\[1\]\[2\] rf\[2\]\[2\] rf\[3\]\[2\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03651_ sky130_fd_sc_hd__mux4_1
X_06102_ rf\[17\]\[17\] _02080_ _02882_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__mux2_1
X_09063__11 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__inv_2
X_07082_ net7 VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__buf_12
X_06033_ _02861_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__clkbuf_1
XFILLER_87_604 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07984_ _04435_ _04437_ _04439_ _04441_ _03231_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__a221o_1
XFILLER_86_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06935_ _03261_ _03444_ VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__or2_1
XFILLER_74_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09723_ net821 _01695_ VGND VGND VPWR VPWR rf\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_09654_ net752 _01626_ VGND VGND VPWR VPWR rf\[27\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_06866_ rf\[16\]\[21\] rf\[17\]\[21\] rf\[18\]\[21\] rf\[19\]\[21\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__mux4_1
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05817_ _02060_ rf\[21\]\[27\] _02745_ VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__mux2_1
XFILLER_82_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09585_ net683 _01557_ VGND VGND VPWR VPWR rf\[25\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_504 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06797_ _03206_ _03313_ VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__or2_4
XFILLER_43_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05748_ _02714_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__clkbuf_1
X_05679_ _02054_ rf\[23\]\[30\] _02677_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__mux2_1
X_08541__578 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__inv_2
X_07418_ _03578_ _03904_ VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__or2_1
X_07349_ _03833_ _03835_ _03837_ _03839_ _03623_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__a221o_2
X_08617__649 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__inv_2
XFILLER_12_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08477__517 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__inv_2
XFILLER_10_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_594 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04473_ _04473_ VGND VGND VPWR VPWR clknet_0__04473_ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04981_ rf\[10\]\[13\] _02088_ _02297_ VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__mux2_1
XFILLER_110_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06720_ _03211_ _03239_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__or2_1
X_06651_ _03179_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__clkbuf_1
X_05602_ _02637_ VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06582_ _02096_ rf\[29\]\[9\] _03122_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__mux2_1
X_09370_ net468 _01342_ VGND VGND VPWR VPWR rf\[18\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05533_ _02601_ VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__clkbuf_1
X_05464_ _02106_ rf\[27\]\[4\] _02537_ VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__mux2_1
X_08501__540 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__inv_2
X_07203_ _03699_ _03700_ _03682_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__o21a_1
X_05395_ _02104_ rf\[28\]\[5\] _02502_ VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__mux2_1
X_07134_ _03580_ _03634_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__or2_1
XFILLER_106_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07065_ _03205_ _03565_ _03567_ _03216_ VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__a31o_1
X_06016_ rf\[18\]\[27\] _02060_ _02848_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__mux2_1
XFILLER_114_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08237__290 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__inv_2
X_07967_ rf\[0\]\[12\] rf\[1\]\[12\] rf\[2\]\[12\] rf\[3\]\[12\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04425_ sky130_fd_sc_hd__mux4_1
XFILLER_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09706_ net804 _01678_ VGND VGND VPWR VPWR rf\[28\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06918_ _03188_ _03428_ _03265_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__o21a_1
X_07898_ _04353_ _04355_ _04357_ _04359_ net5 VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__a221o_1
X_09637_ net735 _01609_ VGND VGND VPWR VPWR rf\[26\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06849_ rf\[12\]\[20\] rf\[13\]\[20\] rf\[14\]\[20\] rf\[15\]\[20\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__mux4_1
X_09568_ net666 _01540_ VGND VGND VPWR VPWR rf\[24\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_1_0__f__04462_ clknet_0__04462_ VGND VGND VPWR VPWR clknet_1_0__leaf__04462_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09499_ net597 _01471_ VGND VGND VPWR VPWR rf\[22\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08524__562 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__inv_2
XTAP_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09018__22 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__inv_2
X_05180_ _02418_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0__04456_ _04456_ VGND VGND VPWR VPWR clknet_0__04456_ sky130_fd_sc_hd__clkbuf_16
X_07821_ _03205_ _04284_ _04286_ _03216_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__a31o_1
X_07752_ _03196_ _04221_ _03265_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__o21a_1
X_04964_ _02307_ VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__clkbuf_1
X_06703_ rf\[20\]\[13\] rf\[21\]\[13\] rf\[22\]\[13\] rf\[23\]\[13\] _03198_ _03199_
+ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__mux4_1
XFILLER_65_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04895_ _02271_ VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07683_ rf\[12\]\[29\] rf\[13\]\[29\] rf\[14\]\[29\] rf\[15\]\[29\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__mux4_1
X_08384__430 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__inv_2
X_09422_ net520 _01394_ VGND VGND VPWR VPWR rf\[20\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06634_ rf\[0\]\[15\] VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__clkbuf_1
X_09353_ net451 _01325_ VGND VGND VPWR VPWR rf\[17\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06565_ _03136_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05516_ _02092_ rf\[26\]\[11\] _02572_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__mux2_1
X_09284_ net382 _01256_ VGND VGND VPWR VPWR rf\[15\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_06496_ rf\[11\]\[19\] net21 _03088_ VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__mux2_1
X_05447_ _02557_ VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05378_ _02521_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07117_ _03603_ _03618_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__or2_1
XFILLER_109_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08811__834 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__inv_2
X_07048_ _03242_ _03551_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__or2_1
XFILLER_125_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08547__584 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__inv_2
XFILLER_43_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04445_ clknet_0__04445_ VGND VGND VPWR VPWR clknet_1_0__leaf__04445_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_678 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08253__305 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__inv_2
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04680_ rf\[19\]\[28\] _02058_ _02154_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__mux2_1
XFILLER_61_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06350_ _03025_ VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__clkbuf_1
X_05301_ _02481_ VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__clkbuf_1
X_06281_ _02060_ rf\[14\]\[27\] _02985_ VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__mux2_1
X_05232_ _02074_ rf\[30\]\[20\] _02434_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__mux2_1
X_08340__388 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__inv_2
XFILLER_116_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05163_ rf\[9\]\[21\] _02072_ _02399_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__mux2_1
XFILLER_115_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09971_ net1069 _01943_ VGND VGND VPWR VPWR rf\[4\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_05094_ _02374_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__clkbuf_1
X_08416__459 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__inv_2
XFILLER_103_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08853_ clknet_1_0__leaf__04490_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__buf_1
X_05996_ rf\[1\]\[4\] _02106_ _02813_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__mux2_1
X_07804_ _03261_ _04270_ VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__or2_1
XFILLER_38_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07735_ _03608_ _04196_ _04205_ _03612_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__o211a_2
X_04947_ rf\[10\]\[30\] _02054_ _02297_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__mux2_1
X_08880__898 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1010 sky130_fd_sc_hd__inv_2
XFILLER_25_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04878_ rf\[6\]\[31\] _02048_ _02262_ VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__mux2_1
X_07666_ _03699_ _04139_ _03682_ VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__o21a_1
X_09405_ net503 _01377_ VGND VGND VPWR VPWR rf\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_07597_ rf\[28\]\[24\] rf\[29\]\[24\] rf\[30\]\[24\] rf\[31\]\[24\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__mux4_2
X_06617_ _03162_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__clkbuf_1
X_09336_ net434 _01308_ VGND VGND VPWR VPWR rf\[17\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_06548_ _02062_ rf\[29\]\[26\] _03122_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__mux2_1
XFILLER_21_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09267_ net365 _01239_ VGND VGND VPWR VPWR rf\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06479_ _03092_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__clkbuf_1
X_09198_ net296 _01170_ VGND VGND VPWR VPWR rf\[13\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_08276__327 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__inv_2
X_08149_ clknet_1_1__leaf__04446_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__buf_1
XFILLER_122_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10042_ net133 _02014_ VGND VGND VPWR VPWR rf\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08300__350 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__inv_2
XFILLER_125_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05850_ _02766_ VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__clkbuf_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04801_ _02220_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__clkbuf_1
X_05781_ _02090_ rf\[22\]\[12\] _02711_ VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__mux2_1
X_07520_ rf\[28\]\[20\] rf\[29\]\[20\] rf\[30\]\[20\] rf\[31\]\[20\] _03691_ _03626_
+ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__mux4_2
XFILLER_81_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08840__860 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__inv_2
X_04732_ rf\[19\]\[2\] _02110_ _02153_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__mux2_1
X_04663_ rf\[3\]\[3\] _02108_ _02118_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__mux2_1
XFILLER_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07451_ rf\[0\]\[17\] rf\[1\]\[17\] rf\[2\]\[17\] rf\[3\]\[17\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03936_ sky130_fd_sc_hd__mux4_2
X_07382_ _03598_ _03870_ _03682_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__o21a_1
X_04594_ net33 VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__buf_12
X_06402_ _03051_ VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__clkbuf_1
X_09121_ net219 _01093_ VGND VGND VPWR VPWR rf\[29\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_06333_ _02112_ rf\[14\]\[1\] _02984_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__mux2_1
XFILLER_30_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08299__349 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__inv_2
X_06264_ _02980_ VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__clkbuf_1
X_05215_ _02437_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__clkbuf_1
X_06195_ _02944_ VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05146_ _02401_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_626 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05077_ rf\[8\]\[31\] _02048_ _02365_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__mux2_1
X_09954_ net1052 _01926_ VGND VGND VPWR VPWR rf\[5\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09885_ net983 _01857_ VGND VGND VPWR VPWR rf\[10\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05979_ _02833_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07718_ _03699_ _04188_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__or2_1
X_07649_ rf\[16\]\[27\] rf\[17\]\[27\] rf\[18\]\[27\] rf\[19\]\[27\] _03582_ _03631_
+ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__mux4_1
XFILLER_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09319_ net417 _01291_ VGND VGND VPWR VPWR rf\[16\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08323__372 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__inv_2
XFILLER_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput64 net64 VGND VGND VPWR VPWR port1_data_o[23] sky130_fd_sc_hd__buf_2
Xoutput53 net53 VGND VGND VPWR VPWR port1_data_o[13] sky130_fd_sc_hd__buf_2
Xoutput75 net75 VGND VGND VPWR VPWR port1_data_o[4] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR port2_data_o[24] sky130_fd_sc_hd__buf_4
Xoutput86 net86 VGND VGND VPWR VPWR port2_data_o[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10025_ net1123 _01997_ VGND VGND VPWR VPWR rf\[19\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08863__882 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__inv_2
XFILLER_36_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_484 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08978__991 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1103 sky130_fd_sc_hd__inv_2
XFILLER_71_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08183__240 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__inv_2
XPHY_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_341 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08259__311 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__inv_2
XFILLER_8_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05000_ _02325_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08610__644 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__inv_2
X_06951_ _03242_ _03459_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__or2_1
X_05902_ rf\[20\]\[18\] _02078_ _02780_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__mux2_1
X_09670_ net768 _01642_ VGND VGND VPWR VPWR rf\[27\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06882_ _03231_ _03385_ _03394_ _03258_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__o211a_1
XFILLER_39_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05833_ _02076_ rf\[21\]\[19\] _02745_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__mux2_1
XFILLER_94_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05764_ _02722_ VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__clkbuf_1
X_04715_ _02175_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07503_ _03979_ _03981_ _03983_ _03985_ _03608_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__a221o_1
X_05695_ _02070_ rf\[23\]\[22\] _02677_ VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__mux2_1
X_07434_ rf\[8\]\[16\] rf\[9\]\[16\] rf\[10\]\[16\] rf\[11\]\[16\] _03604_ _03605_
+ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__mux4_1
XFILLER_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08346__394 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__inv_2
X_04646_ _02139_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__clkbuf_1
X_04577_ _02098_ rf\[31\]\[8\] _02052_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__mux2_1
XFILLER_10_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07365_ _03625_ _03854_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__or2_1
XFILLER_109_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09104_ net202 _01076_ VGND VGND VPWR VPWR rf\[29\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_06316_ _03007_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__clkbuf_1
X_07296_ _03579_ _03788_ _03693_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__o21a_1
X_06247_ _02092_ rf\[15\]\[11\] _02951_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__mux2_1
XFILLER_116_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06178_ rf\[16\]\[12\] _02090_ _02916_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__mux2_1
X_05129_ rf\[8\]\[5\] _02104_ _02364_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__mux2_1
XFILLER_104_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09937_ net1035 _01909_ VGND VGND VPWR VPWR rf\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_09868_ net966 _01840_ VGND VGND VPWR VPWR rf\[7\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08052__115 clknet_1_1__leaf__04449_ VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__inv_2
XFILLER_73_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09799_ net897 _01771_ VGND VGND VPWR VPWR rf\[9\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_627 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08709__737 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__inv_2
X_08215__269 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__inv_2
X_10008_ net1106 _01980_ VGND VGND VPWR VPWR rf\[19\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05480_ _02056_ rf\[26\]\[29\] _02572_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__mux2_1
XFILLER_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07150_ _03623_ _03638_ _03649_ _03650_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__o211a_1
X_06101_ _02896_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__clkbuf_1
X_07081_ _03582_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__buf_12
X_06032_ rf\[18\]\[19\] _02076_ _02848_ VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__mux2_1
X_08569__605 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__inv_2
XFILLER_87_627 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08075__137 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__inv_2
X_07983_ _03196_ _04440_ _03265_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__o21a_1
X_09722_ net820 _01694_ VGND VGND VPWR VPWR rf\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_06934_ rf\[24\]\[24\] rf\[25\]\[24\] rf\[26\]\[24\] rf\[27\]\[24\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__mux4_1
X_09653_ net751 _01625_ VGND VGND VPWR VPWR rf\[27\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06865_ _03271_ _03377_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__or2_1
X_05816_ _02749_ VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__clkbuf_1
X_09584_ net682 _01556_ VGND VGND VPWR VPWR rf\[25\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06796_ rf\[12\]\[17\] rf\[13\]\[17\] rf\[14\]\[17\] rf\[15\]\[17\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__mux4_1
X_05747_ _02056_ rf\[22\]\[29\] _02711_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__mux2_1
XFILLER_23_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05678_ _02678_ VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__clkbuf_1
X_07417_ rf\[16\]\[15\] rf\[17\]\[15\] rf\[18\]\[15\] rf\[19\]\[15\] _03589_ _03584_
+ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__mux4_1
X_04629_ rf\[3\]\[20\] _02074_ _02119_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__mux2_1
XFILLER_50_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07348_ _03588_ _03838_ _03693_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__o21a_1
X_09039__42 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__inv_2
X_07279_ _03580_ _03772_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__or2_1
XFILLER_105_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_627 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08362__409 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__inv_2
XTAP_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08098__159 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__inv_2
XFILLER_123_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__04472_ _04472_ VGND VGND VPWR VPWR clknet_0__04472_ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04980_ _02315_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06650_ rf\[0\]\[7\] VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__clkbuf_1
X_05601_ _02110_ rf\[25\]\[2\] _02606_ VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__mux2_1
XFILLER_91_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06581_ _03144_ VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__clkbuf_1
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05532_ _02108_ rf\[26\]\[3\] _02571_ VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__mux2_1
XFILLER_33_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05463_ _02565_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__clkbuf_1
X_07202_ rf\[4\]\[4\] rf\[5\]\[4\] rf\[6\]\[4\] rf\[7\]\[4\] _03582_ _03626_ VGND
+ VGND VPWR VPWR _03700_ sky130_fd_sc_hd__mux4_2
X_05394_ _02529_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__clkbuf_1
X_07133_ rf\[24\]\[1\] rf\[25\]\[1\] rf\[26\]\[1\] rf\[27\]\[1\] _03590_ _03585_ VGND
+ VGND VPWR VPWR _03634_ sky130_fd_sc_hd__mux4_2
X_07064_ _03211_ _03566_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__or2_1
X_06015_ _02852_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__clkbuf_1
X_08122__182 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__inv_2
XFILLER_102_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07966_ _03231_ _04415_ _04424_ _03220_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__o211a_1
XFILLER_87_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09705_ net803 _01677_ VGND VGND VPWR VPWR rf\[28\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06917_ rf\[8\]\[23\] rf\[9\]\[23\] rf\[10\]\[23\] rf\[11\]\[23\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__mux4_1
X_09636_ net734 _01608_ VGND VGND VPWR VPWR rf\[26\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_07897_ _03271_ _04358_ _03273_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__o21a_1
X_06848_ _03188_ _03359_ _03361_ _03203_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__o211a_1
XFILLER_28_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09567_ net665 _01539_ VGND VGND VPWR VPWR rf\[24\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_06779_ rf\[20\]\[16\] rf\[21\]\[16\] rf\[22\]\[16\] rf\[23\]\[16\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__mux4_1
XFILLER_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04461_ clknet_0__04461_ VGND VGND VPWR VPWR clknet_1_0__leaf__04461_
+ sky130_fd_sc_hd__clkbuf_16
X_09498_ net596 _01470_ VGND VGND VPWR VPWR rf\[22\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_08662__692 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__inv_2
XFILLER_23_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08058__121 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__inv_2
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_416 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07820_ _03211_ _04285_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__or2_1
Xclkbuf_0__04455_ _04455_ VGND VGND VPWR VPWR clknet_0__04455_ sky130_fd_sc_hd__clkbuf_16
X_07751_ rf\[28\]\[0\] rf\[29\]\[0\] rf\[30\]\[0\] rf\[31\]\[0\] _03254_ _03208_ VGND
+ VGND VPWR VPWR _04221_ sky130_fd_sc_hd__mux4_1
X_06702_ _03211_ _03222_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__or2_1
X_04963_ rf\[10\]\[22\] _02070_ _02297_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__mux2_1
XFILLER_65_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07682_ _03580_ _04152_ _04154_ _03595_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__o211a_1
XFILLER_25_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04894_ rf\[6\]\[23\] _02068_ _02262_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__mux2_1
X_06633_ _03170_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__clkbuf_1
X_09421_ net519 _01393_ VGND VGND VPWR VPWR rf\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09352_ net450 _01324_ VGND VGND VPWR VPWR rf\[17\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_06564_ _02078_ rf\[29\]\[18\] _03122_ VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__mux2_1
XFILLER_52_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05515_ _02592_ VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__clkbuf_1
X_09283_ net381 _01255_ VGND VGND VPWR VPWR rf\[15\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_06495_ _03100_ VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__clkbuf_1
X_05446_ _02088_ rf\[27\]\[13\] _02538_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__mux2_1
XFILLER_119_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05377_ _02086_ rf\[28\]\[14\] _02503_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__mux2_1
XFILLER_109_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07116_ rf\[24\]\[0\] rf\[25\]\[0\] rf\[26\]\[0\] rf\[27\]\[0\] _03604_ _03605_ VGND
+ VGND VPWR VPWR _03618_ sky130_fd_sc_hd__mux4_2
XFILLER_4_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07047_ rf\[16\]\[30\] rf\[17\]\[30\] rf\[18\]\[30\] rf\[19\]\[30\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__mux4_1
X_08885__903 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1015 sky130_fd_sc_hd__inv_2
XFILLER_87_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07949_ _03271_ _04407_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__or2_1
XFILLER_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08508__547 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__inv_2
X_09619_ net717 _01591_ VGND VGND VPWR VPWR rf\[26\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04444_ clknet_0__04444_ VGND VGND VPWR VPWR clknet_1_0__leaf__04444_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08972__986 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1098 sky130_fd_sc_hd__inv_2
XFILLER_109_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08368__415 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__inv_2
XFILLER_66_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_611 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_162 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08793__816 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__inv_2
X_05300_ rf\[2\]\[19\] _02076_ _02468_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__mux2_1
X_06280_ _02989_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__clkbuf_1
X_05231_ _02445_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05162_ _02409_ VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__clkbuf_1
X_09970_ net1068 _01942_ VGND VGND VPWR VPWR rf\[4\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_05093_ rf\[8\]\[23\] _02068_ _02365_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__mux2_1
XFILLER_69_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07803_ rf\[16\]\[3\] rf\[17\]\[3\] rf\[18\]\[3\] rf\[19\]\[3\] _03190_ _03244_ VGND
+ VGND VPWR VPWR _04270_ sky130_fd_sc_hd__mux4_1
XFILLER_29_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05995_ _02841_ VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__clkbuf_1
XFILLER_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07734_ _04198_ _04200_ _04202_ _04204_ _03623_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__a221o_1
X_04946_ _02298_ VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__clkbuf_1
XFILLER_65_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07665_ rf\[4\]\[28\] rf\[5\]\[28\] rf\[6\]\[28\] rf\[7\]\[28\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _04139_ sky130_fd_sc_hd__mux4_2
XFILLER_80_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09404_ net502 _01376_ VGND VGND VPWR VPWR rf\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04877_ _02261_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__clkbuf_16
X_06616_ rf\[0\]\[24\] VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__clkbuf_1
XFILLER_80_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07596_ _03629_ _04073_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__or2_1
X_09335_ net433 _01307_ VGND VGND VPWR VPWR rf\[17\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_06547_ _03127_ VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__clkbuf_1
X_06478_ rf\[11\]\[28\] net31 _03088_ VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__mux2_1
X_09266_ net364 _01238_ VGND VGND VPWR VPWR rf\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_08161__219 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__inv_2
X_05429_ _02548_ VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09197_ net295 _01169_ VGND VGND VPWR VPWR rf\[12\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10041_ net132 _02013_ VGND VGND VPWR VPWR rf\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_419 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05780_ _02730_ VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__clkbuf_1
X_04800_ rf\[4\]\[2\] _02110_ _02189_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__mux2_1
X_04731_ _02183_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04662_ _02147_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__clkbuf_1
X_07450_ _03579_ _03934_ net9 VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__o21a_1
X_07381_ rf\[20\]\[13\] rf\[21\]\[13\] rf\[22\]\[13\] rf\[23\]\[13\] _03662_ _03605_
+ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__mux4_2
X_04593_ _02109_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__clkbuf_1
X_06401_ _02114_ rf\[13\]\[0\] _03018_ VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__mux2_1
X_09120_ net218 _01092_ VGND VGND VPWR VPWR rf\[29\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06332_ _03015_ VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__clkbuf_1
X_08916__932 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1044 sky130_fd_sc_hd__inv_2
X_06263_ _02108_ rf\[15\]\[3\] _02950_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__mux2_1
X_05214_ _02056_ rf\[30\]\[29\] _02434_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__mux2_1
X_06194_ rf\[16\]\[4\] _02106_ _02915_ VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__mux2_1
X_05145_ rf\[9\]\[30\] _02054_ _02399_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__mux2_1
XFILLER_104_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05076_ _02364_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__buf_12
X_09953_ net1051 _01925_ VGND VGND VPWR VPWR rf\[5\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09884_ net982 _01856_ VGND VGND VPWR VPWR rf\[10\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05978_ rf\[1\]\[13\] _02088_ _02814_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__mux2_1
XFILLER_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07717_ rf\[4\]\[31\] rf\[5\]\[31\] rf\[6\]\[31\] rf\[7\]\[31\] _03582_ _03626_ VGND
+ VGND VPWR VPWR _04188_ sky130_fd_sc_hd__mux4_1
XFILLER_82_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04929_ _02288_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__clkbuf_1
X_07648_ _03597_ _04120_ _04122_ _03608_ VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__a31o_1
XFILLER_80_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08776__800 clknet_1_1__leaf__04488_ VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__inv_2
X_07579_ _03580_ _04057_ _03693_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__o21a_1
X_09318_ net416 _01290_ VGND VGND VPWR VPWR rf\[16\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_09249_ net347 _01221_ VGND VGND VPWR VPWR rf\[14\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput65 net65 VGND VGND VPWR VPWR port1_data_o[24] sky130_fd_sc_hd__buf_6
Xoutput54 net54 VGND VGND VPWR VPWR port1_data_o[14] sky130_fd_sc_hd__buf_2
Xoutput76 net76 VGND VGND VPWR VPWR port1_data_o[5] sky130_fd_sc_hd__buf_2
XFILLER_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput98 net98 VGND VGND VPWR VPWR port2_data_o[25] sky130_fd_sc_hd__buf_2
XFILLER_103_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput87 net87 VGND VGND VPWR VPWR port2_data_o[15] sky130_fd_sc_hd__buf_2
XFILLER_49_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10024_ net1122 _01996_ VGND VGND VPWR VPWR rf\[19\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08824__845 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__inv_2
XFILLER_72_61 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08939__954 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1066 sky130_fd_sc_hd__inv_2
XFILLER_44_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08144__203 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__inv_2
XFILLER_31_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06950_ rf\[16\]\[25\] rf\[17\]\[25\] rf\[18\]\[25\] rf\[19\]\[25\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__mux4_1
X_05901_ _02793_ VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__clkbuf_1
XFILLER_100_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06881_ _03387_ _03389_ _03391_ _03393_ _03216_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__a221o_1
X_08684__713 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__inv_2
X_05832_ _02757_ VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__clkbuf_1
XFILLER_67_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05763_ _02072_ rf\[22\]\[21\] _02711_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__mux2_1
X_08551_ clknet_1_0__leaf__04468_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__buf_1
XFILLER_82_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08799__822 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__inv_2
X_05694_ _02686_ VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__clkbuf_1
X_04714_ rf\[19\]\[11\] _02092_ _02154_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__mux2_1
X_07502_ _03588_ _03984_ _03595_ VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__o21a_1
X_04645_ rf\[3\]\[12\] _02090_ _02119_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__mux2_1
X_07433_ _03625_ _03918_ VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__or2_1
XFILLER_22_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08307__357 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__inv_2
X_04576_ net41 VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__buf_12
X_07364_ rf\[12\]\[12\] rf\[13\]\[12\] rf\[14\]\[12\] rf\[15\]\[12\] _03630_ _03613_
+ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__mux4_1
XFILLER_22_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09103_ net201 _01075_ VGND VGND VPWR VPWR rf\[29\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07295_ rf\[8\]\[9\] rf\[9\]\[9\] rf\[10\]\[9\] rf\[11\]\[9\] _03691_ _03696_ VGND
+ VGND VPWR VPWR _03788_ sky130_fd_sc_hd__mux4_1
X_06315_ _02094_ rf\[14\]\[10\] _02985_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__mux2_1
X_06246_ _02971_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06177_ _02935_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__clkbuf_1
XFILLER_89_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08771__796 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__inv_2
X_05128_ _02391_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__clkbuf_1
X_05059_ rf\[7\]\[7\] _02100_ _02331_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__mux2_1
X_09936_ net1034 _01908_ VGND VGND VPWR VPWR rf\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_08847__867 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__inv_2
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09867_ net965 _01839_ VGND VGND VPWR VPWR rf\[7\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09798_ net896 _01770_ VGND VGND VPWR VPWR rf\[9\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_61_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08167__225 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__inv_2
XTAP_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08592__626 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__inv_2
XFILLER_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_680 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10007_ net1105 _01979_ VGND VGND VPWR VPWR rf\[19\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_344 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06100_ rf\[17\]\[18\] _02078_ _02882_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__mux2_1
XFILLER_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07080_ _03581_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__buf_12
X_06031_ _02860_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07982_ rf\[28\]\[12\] rf\[29\]\[12\] rf\[30\]\[12\] rf\[31\]\[12\] _03207_ _03208_
+ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__mux4_1
XFILLER_113_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06933_ _03271_ _03442_ _03273_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__o21a_1
XFILLER_87_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09721_ net819 _01693_ VGND VGND VPWR VPWR rf\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08023__88 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__inv_2
X_06864_ rf\[20\]\[21\] rf\[21\]\[21\] rf\[22\]\[21\] rf\[23\]\[21\] _03190_ _03263_
+ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__mux4_1
X_09652_ net750 _01624_ VGND VGND VPWR VPWR rf\[27\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05815_ _02058_ rf\[21\]\[28\] _02745_ VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__mux2_1
X_09583_ net681 _01555_ VGND VGND VPWR VPWR rf\[25\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_06795_ _03203_ _03305_ _03307_ _03309_ _03311_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__a32o_1
X_05746_ _02713_ VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05677_ _02048_ rf\[23\]\[31\] _02677_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__mux2_1
XFILLER_23_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07416_ _03896_ _03898_ _03900_ _03902_ _03608_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__a221o_1
X_04628_ _02130_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_109_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07347_ rf\[28\]\[11\] rf\[29\]\[11\] rf\[30\]\[11\] rf\[31\]\[11\] _03646_ _03591_
+ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__mux4_1
X_04559_ _02086_ rf\[31\]\[14\] _02052_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__mux2_1
XFILLER_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07278_ rf\[24\]\[8\] rf\[25\]\[8\] rf\[26\]\[8\] rf\[27\]\[8\] _03590_ _03585_ VGND
+ VGND VPWR VPWR _03772_ sky130_fd_sc_hd__mux4_1
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06229_ _02074_ rf\[15\]\[20\] _02951_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__mux2_1
XFILLER_117_582 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09919_ net1017 _01891_ VGND VGND VPWR VPWR rf\[6\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08715__742 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__inv_2
Xclkbuf_0__04471_ _04471_ VGND VGND VPWR VPWR clknet_0__04471_ sky130_fd_sc_hd__clkbuf_16
XFILLER_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05600_ _02636_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06580_ _02094_ rf\[29\]\[10\] _03122_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__mux2_1
X_08460__501 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__inv_2
X_05531_ _02600_ VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__clkbuf_1
X_05462_ _02104_ rf\[27\]\[5\] _02537_ VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__mux2_1
X_08250_ clknet_1_0__leaf__04457_ VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__buf_1
XFILLER_60_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07201_ _03587_ VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__buf_8
XFILLER_118_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08575__610 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__inv_2
X_05393_ _02102_ rf\[28\]\[6\] _02503_ VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__mux2_1
X_07132_ _03629_ _03632_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__or2_1
XFILLER_9_492 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07063_ rf\[8\]\[31\] rf\[9\]\[31\] rf\[10\]\[31\] rf\[11\]\[31\] _03212_ _03221_
+ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__mux4_1
X_06014_ rf\[18\]\[28\] _02058_ _02848_ VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__mux2_1
XFILLER_114_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07965_ _04417_ _04419_ _04421_ _04423_ _03216_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__a221o_1
XFILLER_114_47 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09704_ net802 _01676_ VGND VGND VPWR VPWR rf\[28\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_06916_ _03206_ _03426_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__or2_1
X_09635_ net733 _01607_ VGND VGND VPWR VPWR rf\[26\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07896_ rf\[4\]\[8\] rf\[5\]\[8\] rf\[6\]\[8\] rf\[7\]\[8\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _04358_ sky130_fd_sc_hd__mux4_2
XFILLER_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06847_ _03247_ _03360_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__or2_1
XFILLER_55_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09566_ net664 _01538_ VGND VGND VPWR VPWR rf\[24\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_06778_ _03242_ _03295_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__or2_1
Xclkbuf_1_0__f__04460_ clknet_0__04460_ VGND VGND VPWR VPWR clknet_1_0__leaf__04460_
+ sky130_fd_sc_hd__clkbuf_16
X_05729_ _02104_ rf\[23\]\[5\] _02676_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__mux2_1
X_09497_ net595 _01469_ VGND VGND VPWR VPWR rf\[22\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_08623__655 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__inv_2
XFILLER_23_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08738__764 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__inv_2
XFILLER_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_428 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08002__69 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__inv_2
X_08483__523 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__inv_2
XFILLER_74_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08598__632 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__inv_2
XTAP_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08106__167 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__inv_2
XFILLER_6_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08910__927 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1039 sky130_fd_sc_hd__inv_2
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0__04454_ _04454_ VGND VGND VPWR VPWR clknet_0__04454_ sky130_fd_sc_hd__clkbuf_16
X_07750_ _03242_ _04219_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__or2_1
X_04962_ _02306_ VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__clkbuf_1
X_06701_ rf\[16\]\[13\] rf\[17\]\[13\] rf\[18\]\[13\] rf\[19\]\[13\] _03212_ _03221_
+ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__mux4_2
XFILLER_92_450 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08646__677 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__inv_2
X_04893_ _02270_ VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__clkbuf_1
X_07681_ _03598_ _04153_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__or2_1
XFILLER_92_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06632_ rf\[0\]\[16\] VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__clkbuf_1
X_09420_ net518 _01392_ VGND VGND VPWR VPWR rf\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_18_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06563_ _03135_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__clkbuf_1
XFILLER_80_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09351_ net449 _01323_ VGND VGND VPWR VPWR rf\[17\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_05514_ _02090_ rf\[26\]\[12\] _02572_ VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__mux2_1
XFILLER_100_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09282_ net380 _01254_ VGND VGND VPWR VPWR rf\[15\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_572 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06494_ rf\[11\]\[20\] net23 _03088_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__mux2_1
XFILLER_20_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_600 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05445_ _02556_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__clkbuf_1
X_05376_ _02520_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__clkbuf_1
X_07115_ _03588_ _03616_ _03595_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__o21a_1
XFILLER_69_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07046_ _03205_ _03547_ _03549_ _03216_ VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__a31o_1
X_08391__436 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__inv_2
XFILLER_88_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_649 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07948_ rf\[20\]\[11\] rf\[21\]\[11\] rf\[22\]\[11\] rf\[23\]\[11\] _03190_ _03263_
+ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__mux4_1
X_07879_ _03203_ _04335_ _04337_ _04339_ _04341_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__a32o_1
XFILLER_56_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09618_ net716 _01590_ VGND VGND VPWR VPWR rf\[26\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09549_ net647 _01521_ VGND VGND VPWR VPWR rf\[23\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f__04443_ clknet_0__04443_ VGND VGND VPWR VPWR clknet_1_0__leaf__04443_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_71_689 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_603 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_658 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08669__699 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__inv_2
XFILLER_74_483 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_623 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_174 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05230_ _02072_ rf\[30\]\[21\] _02434_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__mux2_1
X_05161_ rf\[9\]\[22\] _02070_ _02399_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__mux2_1
XFILLER_116_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05092_ _02373_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07802_ _03205_ _04266_ _04268_ _03216_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__a31o_1
XFILLER_111_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05994_ rf\[1\]\[5\] _02104_ _02813_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__mux2_1
X_07733_ _03588_ _04203_ _03693_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__o21a_1
X_04945_ rf\[10\]\[31\] _02048_ _02297_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__mux2_1
XFILLER_38_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04876_ _02187_ _02260_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__nor2_4
XFILLER_38_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_686 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07664_ _03579_ _04137_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__or2_1
XFILLER_111_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09403_ net501 _01375_ VGND VGND VPWR VPWR rf\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_06615_ _03161_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07595_ rf\[24\]\[24\] rf\[25\]\[24\] rf\[26\]\[24\] rf\[27\]\[24\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__mux4_2
XFILLER_80_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09334_ net432 _01306_ VGND VGND VPWR VPWR rf\[17\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06546_ _02060_ rf\[29\]\[27\] _03122_ VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__mux2_1
X_06477_ _03091_ VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__clkbuf_1
X_09265_ net363 _01237_ VGND VGND VPWR VPWR rf\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_05428_ _02070_ rf\[27\]\[22\] _02538_ VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__mux2_1
XFILLER_21_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09196_ net294 _01168_ VGND VGND VPWR VPWR rf\[12\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05359_ _02068_ rf\[28\]\[23\] _02503_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__mux2_1
X_07029_ rf\[20\]\[29\] rf\[21\]\[29\] rf\[22\]\[29\] rf\[23\]\[29\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__mux4_1
XFILLER_121_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08514__552 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__inv_2
XFILLER_96_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10040_ net131 _02012_ VGND VGND VPWR VPWR rf\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08629__661 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__inv_2
XFILLER_63_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08374__420 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__inv_2
XFILLER_113_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04730_ rf\[19\]\[3\] _02108_ _02153_ VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__mux2_1
XFILLER_19_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_472 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04661_ rf\[3\]\[4\] _02106_ _02118_ VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__mux2_1
X_08801__824 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__inv_2
XFILLER_35_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06400_ _03050_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__clkbuf_1
X_07380_ _03629_ _03868_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__or2_1
X_04592_ _02108_ rf\[31\]\[3\] _02051_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__mux2_1
XFILLER_22_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06331_ _02110_ rf\[14\]\[2\] _02984_ VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__mux2_1
X_08422__465 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__inv_2
X_06262_ _02979_ VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__clkbuf_1
X_05213_ _02436_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__clkbuf_1
X_06193_ _02943_ VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__clkbuf_1
X_08537__574 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__inv_2
X_05144_ _02400_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__clkbuf_1
X_05075_ _02188_ _02295_ VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__nor2_4
X_09952_ net1050 _01924_ VGND VGND VPWR VPWR rf\[5\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09883_ net981 _01855_ VGND VGND VPWR VPWR rf\[10\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07716_ _03623_ _04178_ _04187_ _03612_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__o211a_2
X_05977_ _02832_ VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04928_ rf\[6\]\[6\] _02102_ _02262_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__mux2_1
XFILLER_26_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07647_ _03603_ _04121_ VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__or2_1
XFILLER_26_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04859_ _02251_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__clkbuf_1
XFILLER_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08282__333 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__inv_2
X_07578_ rf\[8\]\[23\] rf\[9\]\[23\] rf\[10\]\[23\] rf\[11\]\[23\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__mux4_1
X_09317_ net415 _01289_ VGND VGND VPWR VPWR rf\[16\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_06529_ _03117_ VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08397__442 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__inv_2
X_09248_ net346 _01220_ VGND VGND VPWR VPWR rf\[14\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_09179_ net277 _01151_ VGND VGND VPWR VPWR rf\[12\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput66 net66 VGND VGND VPWR VPWR port1_data_o[25] sky130_fd_sc_hd__clkbuf_4
Xoutput55 net55 VGND VGND VPWR VPWR port1_data_o[15] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR port1_data_o[6] sky130_fd_sc_hd__buf_2
Xoutput99 net99 VGND VGND VPWR VPWR port2_data_o[26] sky130_fd_sc_hd__buf_4
Xoutput88 net88 VGND VGND VPWR VPWR port2_data_o[16] sky130_fd_sc_hd__buf_2
XFILLER_88_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10023_ net1121 _01995_ VGND VGND VPWR VPWR rf\[19\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_623 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08445__487 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__inv_2
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05900_ rf\[20\]\[19\] _02076_ _02780_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__mux2_1
X_08190__246 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__inv_2
XFILLER_39_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06880_ _03188_ _03392_ _03205_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__o21a_1
X_05831_ _02074_ rf\[21\]\[20\] _02745_ VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__mux2_1
XFILLER_55_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05762_ _02721_ VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__clkbuf_1
X_05693_ _02068_ rf\[23\]\[23\] _02677_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__mux2_1
X_04713_ _02174_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07501_ rf\[4\]\[19\] rf\[5\]\[19\] rf\[6\]\[19\] rf\[7\]\[19\] _03646_ _03600_ VGND
+ VGND VPWR VPWR _03984_ sky130_fd_sc_hd__mux4_2
X_04644_ _02138_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07432_ rf\[12\]\[16\] rf\[13\]\[16\] rf\[14\]\[16\] rf\[15\]\[16\] _03599_ _03600_
+ VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__mux4_1
X_04575_ _02097_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__clkbuf_1
X_09102_ net200 _01074_ VGND VGND VPWR VPWR rf\[29\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_07363_ _03603_ _03852_ _03682_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__o21a_1
XFILLER_109_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07294_ _03587_ _03786_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__or2_1
X_06314_ _03006_ VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__clkbuf_1
X_09033_ clknet_1_1__leaf__04443_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__buf_1
X_06245_ _02090_ rf\[15\]\[12\] _02951_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__mux2_1
X_06176_ rf\[16\]\[13\] _02088_ _02916_ VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__mux2_1
X_05127_ rf\[8\]\[6\] _02102_ _02365_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__mux2_1
XFILLER_117_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05058_ _02355_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__clkbuf_1
X_09935_ net1033 _01907_ VGND VGND VPWR VPWR rf\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09866_ net964 _01838_ VGND VGND VPWR VPWR rf\[7\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09797_ net895 _01769_ VGND VGND VPWR VPWR rf\[9\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_692 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10006_ net1104 _01978_ VGND VGND VPWR VPWR rf\[19\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_707 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_710 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_162 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06030_ rf\[18\]\[20\] _02074_ _02848_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__mux2_1
XFILLER_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07981_ _03242_ _04438_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__or2_1
X_06932_ rf\[20\]\[24\] rf\[21\]\[24\] rf\[22\]\[24\] rf\[23\]\[24\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__mux4_1
X_09720_ net818 _01692_ VGND VGND VPWR VPWR rf\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_09651_ net749 _01623_ VGND VGND VPWR VPWR rf\[27\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06863_ _03362_ _03367_ _03376_ _03258_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__o211a_1
X_08313__362 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__inv_2
X_08807__830 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__inv_2
X_05814_ _02748_ VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__clkbuf_1
X_09582_ net680 _01554_ VGND VGND VPWR VPWR rf\[25\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_06794_ _03196_ _03310_ _03205_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__o21a_1
XFILLER_82_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05745_ _02054_ rf\[22\]\[30\] _02711_ VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__mux2_1
X_08428__471 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__inv_2
XFILLER_63_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05676_ _02676_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__buf_12
X_07415_ _03699_ _03901_ _03682_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__o21a_1
X_04627_ rf\[3\]\[21\] _02072_ _02119_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__mux2_1
X_07346_ _03629_ _03836_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__or2_1
X_04558_ net16 VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__buf_12
X_07277_ _03629_ _03770_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__or2_1
XFILLER_117_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06228_ _02962_ VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06159_ _02926_ VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_120_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09918_ net1016 _01890_ VGND VGND VPWR VPWR rf\[6\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_08173__230 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__inv_2
XFILLER_19_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09849_ net947 _01821_ VGND VGND VPWR VPWR rf\[7\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08600__634 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__inv_2
X_08221__275 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__inv_2
XFILLER_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0__04470_ _04470_ VGND VGND VPWR VPWR clknet_0__04470_ sky130_fd_sc_hd__clkbuf_16
X_08336__384 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__inv_2
XFILLER_110_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05530_ _02106_ rf\[26\]\[4\] _02571_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__mux2_1
XFILLER_17_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05461_ _02564_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05392_ _02528_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__clkbuf_1
X_07200_ _03579_ _03697_ VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__or2_1
X_08876__894 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1006 sky130_fd_sc_hd__inv_2
XFILLER_20_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07131_ rf\[16\]\[1\] rf\[17\]\[1\] rf\[18\]\[1\] rf\[19\]\[1\] _03630_ _03631_ VGND
+ VGND VPWR VPWR _03632_ sky130_fd_sc_hd__mux4_1
XFILLER_9_471 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08081__143 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__inv_2
X_07062_ _03206_ _03564_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__or2_1
X_06013_ _02851_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__clkbuf_1
X_08196__252 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__inv_2
XFILLER_114_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04499_ clknet_0__04499_ VGND VGND VPWR VPWR clknet_1_1__leaf__04499_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_68_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07964_ _03188_ _04422_ _03265_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__o21a_1
X_09703_ net801 _01675_ VGND VGND VPWR VPWR rf\[28\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07895_ _03261_ _04356_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__or2_1
X_06915_ rf\[12\]\[23\] rf\[13\]\[23\] rf\[14\]\[23\] rf\[15\]\[23\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__mux4_1
X_09634_ net732 _01606_ VGND VGND VPWR VPWR rf\[26\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_114_59 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06846_ rf\[4\]\[20\] rf\[5\]\[20\] rf\[6\]\[20\] rf\[7\]\[20\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03360_ sky130_fd_sc_hd__mux4_1
X_09565_ net663 _01537_ VGND VGND VPWR VPWR rf\[24\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_06777_ rf\[16\]\[16\] rf\[17\]\[16\] rf\[18\]\[16\] rf\[19\]\[16\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__mux4_1
XFILLER_70_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05728_ _02703_ VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__clkbuf_1
X_09496_ net594 _01468_ VGND VGND VPWR VPWR rf\[22\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05659_ _02667_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__clkbuf_1
XFILLER_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08244__297 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__inv_2
X_07329_ _03588_ _03820_ _03693_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__o21a_1
XFILLER_105_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_687 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0__04453_ _04453_ VGND VGND VPWR VPWR clknet_0__04453_ sky130_fd_sc_hd__clkbuf_16
XFILLER_1_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04961_ rf\[10\]\[23\] _02068_ _02297_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__mux2_1
X_06700_ _03192_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__buf_12
X_04892_ rf\[6\]\[24\] _02066_ _02262_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__mux2_1
X_07680_ rf\[4\]\[29\] rf\[5\]\[29\] rf\[6\]\[29\] rf\[7\]\[29\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _04153_ sky130_fd_sc_hd__mux4_1
XFILLER_92_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06631_ _03169_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__clkbuf_1
X_06562_ _02076_ rf\[29\]\[19\] _03122_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__mux2_1
X_09350_ net448 _01322_ VGND VGND VPWR VPWR rf\[17\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_05513_ _02591_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__clkbuf_1
X_09281_ net379 _01253_ VGND VGND VPWR VPWR rf\[15\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_702 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06493_ _03099_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05444_ _02086_ rf\[27\]\[14\] _02538_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__mux2_1
X_05375_ _02084_ rf\[28\]\[15\] _02503_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__mux2_1
X_07114_ rf\[20\]\[0\] rf\[21\]\[0\] rf\[22\]\[0\] rf\[23\]\[0\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03616_ sky130_fd_sc_hd__mux4_2
XFILLER_9_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07045_ _03211_ _03548_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__or2_1
X_09024__28 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__inv_2
XFILLER_125_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_201 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_628 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07947_ _04392_ _04397_ _04406_ _03220_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__o211a_1
X_07991__58 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__inv_2
X_08467__508 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__inv_2
XFILLER_87_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07878_ _03196_ _04340_ _03205_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__o21a_1
XFILLER_56_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09617_ net715 _01589_ VGND VGND VPWR VPWR rf\[26\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06829_ _03188_ _03341_ _03343_ _03203_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__o211a_1
XFILLER_56_687 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09548_ net646 _01520_ VGND VGND VPWR VPWR rf\[23\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09479_ net577 _01451_ VGND VGND VPWR VPWR rf\[21\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_278 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08606__640 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__inv_2
XFILLER_74_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08112__172 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__inv_2
XFILLER_61_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08227__281 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__inv_2
XFILLER_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05160_ _02408_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05091_ rf\[8\]\[24\] _02066_ _02365_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__mux2_1
XFILLER_124_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_532 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07801_ _03211_ _04267_ VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__or2_1
X_05993_ _02840_ VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07732_ rf\[28\]\[31\] rf\[29\]\[31\] rf\[30\]\[31\] rf\[31\]\[31\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__mux4_1
X_04944_ _02296_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__buf_12
XFILLER_53_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04875_ net44 _02259_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__or2_4
XFILLER_38_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07663_ rf\[0\]\[28\] rf\[1\]\[28\] rf\[2\]\[28\] rf\[3\]\[28\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _04137_ sky130_fd_sc_hd__mux4_1
XFILLER_111_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09402_ net500 _01374_ VGND VGND VPWR VPWR rf\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_06614_ rf\[0\]\[25\] VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07594_ _03598_ _04071_ _03682_ VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__o21a_1
X_09333_ net431 _01305_ VGND VGND VPWR VPWR rf\[17\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06545_ _03126_ VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__clkbuf_1
X_06476_ rf\[11\]\[29\] net32 _03088_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__mux2_1
X_09264_ net362 _01236_ VGND VGND VPWR VPWR rf\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_05427_ _02547_ VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__clkbuf_1
X_09195_ net293 _01167_ VGND VGND VPWR VPWR rf\[12\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05358_ _02511_ VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__clkbuf_1
XFILLER_106_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05289_ _02475_ VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__clkbuf_1
X_07028_ _03187_ _03532_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__or2_1
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08135__194 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__inv_2
XFILLER_29_687 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_705 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_484 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04660_ _02146_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_605 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04591_ net36 VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__buf_12
XTAP_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06330_ _03014_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__clkbuf_1
X_06261_ _02106_ rf\[15\]\[4\] _02950_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__mux2_1
X_05212_ _02054_ rf\[30\]\[30\] _02434_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__mux2_1
X_06192_ rf\[16\]\[5\] _02104_ _02915_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__mux2_1
X_05143_ rf\[9\]\[31\] _02048_ _02399_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__mux2_1
X_05074_ _02363_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__clkbuf_1
X_09951_ net1049 _01923_ VGND VGND VPWR VPWR rf\[5\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09882_ net980 _01854_ VGND VGND VPWR VPWR rf\[10\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08833_ clknet_1_0__leaf__04490_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__buf_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05976_ rf\[1\]\[14\] _02086_ _02814_ VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__mux2_1
X_08962__976 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1088 sky130_fd_sc_hd__inv_2
XTAP_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04927_ _02287_ VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__clkbuf_1
X_07715_ _04180_ _04182_ _04184_ _04186_ _03608_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__a221o_1
XFILLER_81_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_465 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07646_ rf\[8\]\[27\] rf\[9\]\[27\] rf\[10\]\[27\] rf\[11\]\[27\] _03604_ _03613_
+ VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__mux4_1
X_04858_ rf\[5\]\[7\] _02100_ _02226_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__mux2_1
X_04789_ _02214_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__clkbuf_1
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07577_ _03625_ _04055_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__or2_1
X_09316_ net414 _01288_ VGND VGND VPWR VPWR rf\[16\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_06528_ rf\[11\]\[3\] net36 _03087_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__mux2_1
X_09247_ net345 _01219_ VGND VGND VPWR VPWR rf\[14\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_06459_ _03081_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__clkbuf_1
X_08358__405 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__inv_2
X_09178_ net276 _01150_ VGND VGND VPWR VPWR rf\[12\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08129_ clknet_1_0__leaf__04446_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__buf_1
Xoutput67 net67 VGND VGND VPWR VPWR port1_data_o[26] sky130_fd_sc_hd__buf_6
Xoutput56 net56 VGND VGND VPWR VPWR port1_data_o[16] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR port1_data_o[7] sky130_fd_sc_hd__buf_2
Xoutput89 net89 VGND VGND VPWR VPWR port2_data_o[17] sky130_fd_sc_hd__buf_6
XFILLER_49_705 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10022_ net1120 _01994_ VGND VGND VPWR VPWR rf\[19\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_568 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_635 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08898__915 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1027 sky130_fd_sc_hd__inv_2
XFILLER_32_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08870__889 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__inv_2
XFILLER_125_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08985__998 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1110 sky130_fd_sc_hd__inv_2
XFILLER_67_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05830_ _02756_ VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_708 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08151__209 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__inv_2
X_05761_ _02070_ rf\[22\]\[22\] _02711_ VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__mux2_1
XFILLER_63_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07500_ _03629_ _03982_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__or2_1
X_05692_ _02685_ VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__clkbuf_1
X_04712_ rf\[19\]\[12\] _02090_ _02154_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__mux2_1
X_08266__318 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__inv_2
XFILLER_23_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07431_ _03580_ _03914_ _03916_ _03595_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__o211a_2
X_04643_ rf\[3\]\[13\] _02088_ _02119_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__mux2_1
X_07362_ rf\[0\]\[12\] rf\[1\]\[12\] rf\[2\]\[12\] rf\[3\]\[12\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _03852_ sky130_fd_sc_hd__mux4_2
XFILLER_22_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04574_ _02096_ rf\[31\]\[9\] _02052_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__mux2_1
X_06313_ _02092_ rf\[14\]\[11\] _02985_ VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__mux2_1
X_09101_ net199 _01073_ VGND VGND VPWR VPWR rf\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_07293_ rf\[12\]\[9\] rf\[13\]\[9\] rf\[14\]\[9\] rf\[15\]\[9\] _03589_ _03584_ VGND
+ VGND VPWR VPWR _03786_ sky130_fd_sc_hd__mux4_1
XFILLER_117_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06244_ _02970_ VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__clkbuf_1
X_06175_ _02934_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05126_ _02390_ VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__clkbuf_1
X_05057_ rf\[7\]\[8\] _02098_ _02331_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__mux2_1
X_09934_ net1032 _01906_ VGND VGND VPWR VPWR rf\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_610 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09865_ net963 _01837_ VGND VGND VPWR VPWR rf\[7\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09796_ net894 _01768_ VGND VGND VPWR VPWR rf\[9\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_05959_ _02823_ VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__clkbuf_1
XTAP_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07629_ rf\[16\]\[26\] rf\[17\]\[26\] rf\[18\]\[26\] rf\[19\]\[26\] _03589_ _03584_
+ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__mux4_1
XTAP_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08405__450 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__inv_2
XFILLER_42_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08830__851 clknet_1_1__leaf__04491_ VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__inv_2
XFILLER_3_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10005_ net1103 _01977_ VGND VGND VPWR VPWR rf\[19\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08945__960 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1072 sky130_fd_sc_hd__inv_2
XFILLER_1_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_722 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_660 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07980_ rf\[24\]\[12\] rf\[25\]\[12\] rf\[26\]\[12\] rf\[27\]\[12\] _03243_ _03244_
+ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__mux4_1
X_06931_ _03187_ _03440_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__or2_1
X_09650_ net748 _01622_ VGND VGND VPWR VPWR rf\[27\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06862_ _03369_ _03371_ _03373_ _03375_ _03231_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__a221o_1
XFILLER_55_516 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05813_ _02056_ rf\[21\]\[29\] _02745_ VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__mux2_1
X_09581_ net679 _01553_ VGND VGND VPWR VPWR rf\[24\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06793_ rf\[28\]\[17\] rf\[29\]\[17\] rf\[30\]\[17\] rf\[31\]\[17\] _03191_ _03193_
+ VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__mux4_1
X_05744_ _02712_ VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05675_ _02050_ _02675_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__nand2_4
X_07414_ rf\[4\]\[15\] rf\[5\]\[15\] rf\[6\]\[15\] rf\[7\]\[15\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _03901_ sky130_fd_sc_hd__mux4_2
X_04626_ _02129_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_11_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07345_ rf\[24\]\[11\] rf\[25\]\[11\] rf\[26\]\[11\] rf\[27\]\[11\] _03630_ _03613_
+ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__mux4_1
X_04557_ _02085_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__clkbuf_1
X_07276_ rf\[16\]\[8\] rf\[17\]\[8\] rf\[18\]\[8\] rf\[19\]\[8\] _03630_ _03631_ VGND
+ VGND VPWR VPWR _03770_ sky130_fd_sc_hd__mux4_1
X_06227_ _02072_ rf\[15\]\[21\] _02951_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__mux2_1
X_08814__835 clknet_1_1__leaf__04491_ VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__inv_2
XFILLER_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06158_ rf\[16\]\[22\] _02070_ _02916_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__mux2_1
XFILLER_2_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06089_ _02890_ VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__clkbuf_1
X_05109_ rf\[8\]\[15\] _02084_ _02365_ VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__mux2_1
X_08968__982 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1094 sky130_fd_sc_hd__inv_2
X_09917_ net1015 _01889_ VGND VGND VPWR VPWR rf\[6\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_08014__79 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__inv_2
XFILLER_58_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09848_ net946 _01820_ VGND VGND VPWR VPWR rf\[7\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_22 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09779_ net877 _01751_ VGND VGND VPWR VPWR rf\[9\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08249__302 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__inv_2
XFILLER_27_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08674__703 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__inv_2
XFILLER_6_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09045__48 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__inv_2
XFILLER_108_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07997__64 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__inv_2
XFILLER_118_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08761__786 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__inv_2
XFILLER_45_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05460_ _02102_ rf\[27\]\[6\] _02538_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__mux2_1
X_05391_ _02100_ rf\[28\]\[7\] _02503_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__mux2_1
X_07130_ net7 VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__buf_12
X_08837__857 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__inv_2
XFILLER_118_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08042__106 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__inv_2
XFILLER_9_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07061_ rf\[12\]\[31\] rf\[13\]\[31\] rf\[14\]\[31\] rf\[15\]\[31\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__mux4_1
X_06012_ rf\[18\]\[29\] _02056_ _02848_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__mux2_1
XFILLER_99_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08157__215 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__inv_2
XFILLER_101_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07963_ rf\[8\]\[11\] rf\[9\]\[11\] rf\[10\]\[11\] rf\[11\]\[11\] _03207_ _03208_
+ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04498_ clknet_0__04498_ VGND VGND VPWR VPWR clknet_1_1__leaf__04498_
+ sky130_fd_sc_hd__clkbuf_16
X_09702_ net800 _01674_ VGND VGND VPWR VPWR rf\[28\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06914_ _03211_ _03424_ _03273_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__o21a_1
X_07894_ rf\[0\]\[8\] rf\[1\]\[8\] rf\[2\]\[8\] rf\[3\]\[8\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04356_ sky130_fd_sc_hd__mux4_1
X_09633_ net731 _01605_ VGND VGND VPWR VPWR rf\[26\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06845_ rf\[0\]\[20\] rf\[1\]\[20\] rf\[2\]\[20\] rf\[3\]\[20\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03359_ sky130_fd_sc_hd__mux4_1
X_09564_ net662 _01536_ VGND VGND VPWR VPWR rf\[24\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06776_ _03205_ _03291_ _03293_ _03216_ VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__a31o_2
XFILLER_36_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05727_ _02102_ rf\[23\]\[6\] _02677_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__mux2_1
X_09495_ net593 _01467_ VGND VGND VPWR VPWR rf\[22\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05658_ rf\[24\]\[7\] _02100_ _02642_ VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__mux2_1
X_08697__725 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__inv_2
XFILLER_23_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04609_ rf\[3\]\[30\] _02054_ _02119_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__mux2_1
X_05589_ _02098_ rf\[25\]\[8\] _02607_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__mux2_1
X_07328_ rf\[28\]\[10\] rf\[29\]\[10\] rf\[30\]\[10\] rf\[31\]\[10\] _03646_ _03591_
+ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__mux4_1
XFILLER_7_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07259_ rf\[12\]\[7\] rf\[13\]\[7\] rf\[14\]\[7\] rf\[15\]\[7\] _03599_ _03600_ VGND
+ VGND VPWR VPWR _03754_ sky130_fd_sc_hd__mux4_1
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08065__128 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__inv_2
XFILLER_30_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04452_ _04452_ VGND VGND VPWR VPWR clknet_0__04452_ sky130_fd_sc_hd__clkbuf_16
XFILLER_111_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04960_ _02305_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__clkbuf_1
XFILLER_65_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04891_ _02269_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__clkbuf_1
X_06630_ rf\[0\]\[17\] VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__clkbuf_1
X_06561_ _03134_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__clkbuf_1
X_05512_ _02088_ rf\[26\]\[13\] _02572_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__mux2_1
X_06492_ rf\[11\]\[21\] net24 _03088_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__mux2_1
XFILLER_21_714 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09280_ net378 _01252_ VGND VGND VPWR VPWR rf\[15\]\[18\] sky130_fd_sc_hd__dfxtp_2
X_05443_ _02555_ VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__clkbuf_1
X_05374_ _02519_ VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__clkbuf_1
X_07113_ _03603_ _03614_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__or2_1
X_08204__260 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__inv_2
X_07044_ rf\[8\]\[30\] rf\[9\]\[30\] rf\[10\]\[30\] rf\[11\]\[30\] _03212_ _03221_
+ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__mux4_1
XFILLER_114_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07946_ _04399_ _04401_ _04403_ _04405_ _03231_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__a221o_1
XFILLER_68_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07877_ rf\[28\]\[7\] rf\[29\]\[7\] rf\[30\]\[7\] rf\[31\]\[7\] _03198_ _03193_ VGND
+ VGND VPWR VPWR _04340_ sky130_fd_sc_hd__mux4_1
X_09616_ net714 _01588_ VGND VGND VPWR VPWR rf\[26\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08744__770 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__inv_2
X_06828_ _03247_ _03342_ VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__or2_1
X_09547_ net645 _01519_ VGND VGND VPWR VPWR rf\[23\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_06759_ rf\[20\]\[15\] rf\[21\]\[15\] rf\[22\]\[15\] rf\[23\]\[15\] _03262_ _03268_
+ VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__mux4_1
X_09478_ net576 _01450_ VGND VGND VPWR VPWR rf\[21\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05090_ _02372_ VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__clkbuf_1
X_08613__645 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__inv_2
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07800_ rf\[8\]\[3\] rf\[9\]\[3\] rf\[10\]\[3\] rf\[11\]\[3\] _03212_ _03221_ VGND
+ VGND VPWR VPWR _04267_ sky130_fd_sc_hd__mux4_1
XFILLER_111_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07731_ _03629_ _04201_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__or2_1
X_05992_ rf\[1\]\[6\] _02102_ _02814_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__mux2_1
X_08767__792 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__inv_2
XFILLER_38_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04943_ _02260_ _02295_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__nor2_4
X_04874_ net45 net43 VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__nand2_2
X_07662_ _03579_ _04135_ net9 VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__o21a_1
X_07593_ rf\[20\]\[24\] rf\[21\]\[24\] rf\[22\]\[24\] rf\[23\]\[24\] _03662_ _03605_
+ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__mux4_1
XFILLER_92_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06613_ _03160_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__clkbuf_1
X_09401_ net499 _01373_ VGND VGND VPWR VPWR rf\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_09332_ net430 _01304_ VGND VGND VPWR VPWR rf\[17\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_18_390 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06544_ _02058_ rf\[29\]\[28\] _03122_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__mux2_1
X_08048__112 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__inv_2
XFILLER_33_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06475_ _03090_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__clkbuf_1
X_09263_ net361 _01235_ VGND VGND VPWR VPWR rf\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_05426_ _02068_ rf\[27\]\[23\] _02538_ VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__mux2_1
X_09194_ net292 _01166_ VGND VGND VPWR VPWR rf\[12\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_05357_ _02066_ rf\[28\]\[24\] _02503_ VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__mux2_1
X_08473__513 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__inv_2
X_05288_ rf\[2\]\[25\] _02064_ _02468_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__mux2_1
XFILLER_20_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07027_ rf\[16\]\[29\] rf\[17\]\[29\] rf\[18\]\[29\] rf\[19\]\[29\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__mux4_1
XFILLER_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07929_ rf\[0\]\[10\] rf\[1\]\[10\] rf\[2\]\[10\] rf\[3\]\[10\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04389_ sky130_fd_sc_hd__mux4_1
XFILLER_29_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_699 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08900__917 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1029 sky130_fd_sc_hd__inv_2
XFILLER_45_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08560__596 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__inv_2
XFILLER_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08636__667 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__inv_2
XFILLER_106_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_577 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_603 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04590_ _02107_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06260_ _02978_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__clkbuf_1
X_08496__535 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__inv_2
X_05211_ _02435_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__clkbuf_1
X_06191_ _02942_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_424 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05142_ _02398_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__buf_12
X_05073_ rf\[7\]\[0\] _02114_ _02330_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__mux2_1
X_09950_ net1048 _01922_ VGND VGND VPWR VPWR rf\[5\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09881_ net979 _01853_ VGND VGND VPWR VPWR rf\[10\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08119__179 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__inv_2
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05975_ _02831_ VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__clkbuf_1
XFILLER_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04926_ rf\[6\]\[7\] _02100_ _02262_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__mux2_1
X_08923__939 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1051 sky130_fd_sc_hd__inv_2
XFILLER_38_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07714_ _03588_ _04185_ _03595_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__o21a_1
XFILLER_65_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04857_ _02250_ VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__clkbuf_1
X_07645_ _03625_ _04119_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__or2_1
X_04788_ rf\[4\]\[8\] _02098_ _02190_ VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__mux2_1
XFILLER_41_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07576_ rf\[12\]\[23\] rf\[13\]\[23\] rf\[14\]\[23\] rf\[15\]\[23\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__mux4_1
X_09315_ net413 _01287_ VGND VGND VPWR VPWR rf\[16\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_80_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06527_ _03116_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06458_ rf\[12\]\[5\] _02104_ _03053_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__mux2_1
X_09246_ net344 _01218_ VGND VGND VPWR VPWR rf\[14\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_05409_ _02537_ VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__buf_12
X_08659__689 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__inv_2
XFILLER_119_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09177_ net275 _01149_ VGND VGND VPWR VPWR rf\[12\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_06389_ _02102_ rf\[13\]\[6\] _03019_ VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__mux2_1
XFILLER_31_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput57 net57 VGND VGND VPWR VPWR port1_data_o[17] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR port1_data_o[27] sky130_fd_sc_hd__buf_2
Xoutput79 net79 VGND VGND VPWR VPWR port1_data_o[8] sky130_fd_sc_hd__buf_2
XFILLER_103_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10021_ net1119 _01993_ VGND VGND VPWR VPWR rf\[19\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08783__807 clknet_1_1__leaf__04488_ VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__inv_2
XFILLER_49_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_647 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_691 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08035__99 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__inv_2
XFILLER_79_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05760_ _02720_ VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__clkbuf_1
X_04711_ _02173_ VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05691_ _02066_ rf\[23\]\[24\] _02677_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__mux2_1
X_04642_ _02137_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__clkbuf_1
XFILLER_35_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07430_ _03598_ _03915_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__or2_1
XFILLER_50_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08543__580 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__inv_2
X_04573_ net42 VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__buf_12
X_07361_ _03625_ _03850_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__or2_1
X_09100_ net198 _01072_ VGND VGND VPWR VPWR rf\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_06312_ _03005_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__clkbuf_1
X_07292_ _03623_ _03776_ _03785_ _03650_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__o211a_1
X_06243_ _02088_ rf\[15\]\[13\] _02951_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__mux2_1
X_08619__651 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__inv_2
X_06174_ rf\[16\]\[14\] _02086_ _02916_ VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__mux2_1
XFILLER_117_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05125_ rf\[8\]\[7\] _02100_ _02365_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__mux2_1
XFILLER_104_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05056_ _02354_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__clkbuf_1
X_09933_ net1031 _01905_ VGND VGND VPWR VPWR rf\[6\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09864_ net962 _01836_ VGND VGND VPWR VPWR rf\[7\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_622 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09795_ net893 _01767_ VGND VGND VPWR VPWR rf\[9\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05958_ rf\[1\]\[23\] _02068_ _02814_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__mux2_1
X_05889_ _02787_ VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__clkbuf_1
XTAP_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04909_ _02278_ VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__clkbuf_1
XTAP_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07628_ _04097_ _04099_ _04101_ _04103_ net10 VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__a221o_1
X_07559_ rf\[28\]\[22\] rf\[29\]\[22\] rf\[30\]\[22\] rf\[31\]\[22\] _03646_ _03600_
+ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__mux4_2
X_09229_ net327 _01201_ VGND VGND VPWR VPWR rf\[13\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10004_ net1102 _01976_ VGND VGND VPWR VPWR rf\[19\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_08412__455 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__inv_2
X_08906__923 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1035 sky130_fd_sc_hd__inv_2
XFILLER_64_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08272__323 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__inv_2
X_06930_ rf\[16\]\[24\] rf\[17\]\[24\] rf\[18\]\[24\] rf\[19\]\[24\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__mux4_1
XFILLER_95_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06861_ _03196_ _03374_ _03205_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__o21a_1
X_05812_ _02747_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__clkbuf_1
X_09580_ net678 _01552_ VGND VGND VPWR VPWR rf\[24\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06792_ _03188_ _03308_ VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__or2_1
XFILLER_55_528 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05743_ _02048_ rf\[22\]\[31\] _02711_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__mux2_1
X_08531_ clknet_1_0__leaf__04468_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__buf_1
X_05674_ net47 net46 net48 VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__and3b_4
X_04625_ rf\[3\]\[22\] _02070_ _02119_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__mux2_1
X_07413_ _03579_ _03899_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__or2_1
X_07344_ _03598_ _03834_ _03682_ VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__o21a_1
X_04556_ _02084_ rf\[31\]\[15\] _02052_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__mux2_1
X_07275_ _03625_ _03768_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__or2_1
XFILLER_12_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06226_ _02961_ VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06157_ _02925_ VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__clkbuf_1
XFILLER_2_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06088_ rf\[17\]\[24\] _02066_ _02882_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__mux2_1
X_05108_ _02381_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08435__477 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__inv_2
X_09916_ net1014 _01888_ VGND VGND VPWR VPWR rf\[6\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_05039_ rf\[7\]\[17\] _02080_ _02331_ VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__mux2_1
X_08929__945 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1057 sky130_fd_sc_hd__inv_2
XFILLER_98_480 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09847_ net945 _01819_ VGND VGND VPWR VPWR rf\[7\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09778_ net876 _01750_ VGND VGND VPWR VPWR rf\[9\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08295__345 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__inv_2
X_08789__813 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__inv_2
XFILLER_5_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_642 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08722__749 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__inv_2
XFILLER_32_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05390_ _02527_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__clkbuf_1
XFILLER_71_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07060_ _03188_ _03560_ _03562_ _03203_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__o211a_1
X_06011_ _02850_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__clkbuf_1
X_08458__499 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__inv_2
X_09701_ net799 _01673_ VGND VGND VPWR VPWR rf\[28\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_1_1__f__04497_ clknet_0__04497_ VGND VGND VPWR VPWR clknet_1_1__leaf__04497_
+ sky130_fd_sc_hd__clkbuf_16
X_07962_ _03206_ _04420_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__or2_1
XFILLER_68_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07893_ _03261_ _04354_ net4 VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__o21a_1
X_06913_ rf\[0\]\[23\] rf\[1\]\[23\] rf\[2\]\[23\] rf\[3\]\[23\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _03424_ sky130_fd_sc_hd__mux4_1
X_09632_ net730 _01604_ VGND VGND VPWR VPWR rf\[26\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06844_ _03344_ _03349_ _03358_ _03258_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__o211a_1
X_08582__617 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__inv_2
X_09563_ net661 _01535_ VGND VGND VPWR VPWR rf\[24\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06775_ _03211_ _03292_ VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__or2_1
XFILLER_24_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05726_ _02702_ VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__clkbuf_1
X_09494_ net592 _01466_ VGND VGND VPWR VPWR rf\[22\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05657_ _02666_ VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__clkbuf_1
X_05588_ _02630_ VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__clkbuf_1
X_04608_ _02120_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__clkbuf_1
X_07327_ _03629_ _03818_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__or2_1
X_04539_ _02073_ VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_109_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07258_ _03580_ _03750_ _03752_ _03595_ VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__o211a_1
XFILLER_124_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_360 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07189_ _03680_ _03683_ _03685_ _03687_ _03608_ VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__a221o_1
X_06209_ _02054_ rf\[15\]\[30\] _02951_ VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__mux2_1
XFILLER_120_558 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08342__390 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__inv_2
XFILLER_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08418__461 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__inv_2
Xclkbuf_0__04451_ _04451_ VGND VGND VPWR VPWR clknet_0__04451_ sky130_fd_sc_hd__clkbuf_16
XFILLER_123_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04890_ rf\[6\]\[25\] _02064_ _02262_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__mux2_1
XFILLER_49_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06560_ _02074_ rf\[29\]\[20\] _03122_ VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__mux2_1
XFILLER_80_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05511_ _02590_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__clkbuf_1
X_06491_ _03098_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__clkbuf_1
X_05442_ _02084_ rf\[27\]\[15\] _02538_ VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__mux2_1
X_08230_ clknet_1_0__leaf__04457_ VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__buf_1
XFILLER_21_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05373_ _02082_ rf\[28\]\[16\] _02503_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__mux2_1
XFILLER_118_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07112_ rf\[16\]\[0\] rf\[17\]\[0\] rf\[18\]\[0\] rf\[19\]\[0\] _03604_ _03613_ VGND
+ VGND VPWR VPWR _03614_ sky130_fd_sc_hd__mux4_1
XFILLER_109_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07043_ _03206_ _03546_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__or2_1
XFILLER_0_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07945_ _03196_ _04404_ _03265_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__o21a_1
X_09615_ net713 _01587_ VGND VGND VPWR VPWR rf\[26\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_07876_ _03188_ _04338_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__or2_1
XFILLER_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_626 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06827_ rf\[4\]\[19\] rf\[5\]\[19\] rf\[6\]\[19\] rf\[7\]\[19\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03342_ sky130_fd_sc_hd__mux4_1
X_09546_ net644 _01518_ VGND VGND VPWR VPWR rf\[23\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06758_ _03187_ _03276_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__or2_4
XFILLER_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08705__733 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__inv_2
X_08211__265 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__inv_2
X_09477_ net575 _01449_ VGND VGND VPWR VPWR rf\[21\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_05709_ _02084_ rf\[23\]\[15\] _02677_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__mux2_1
XFILLER_24_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06689_ _03206_ _03209_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__or2_1
XFILLER_51_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09015__19 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__inv_2
XFILLER_1_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08565__601 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__inv_2
X_08071__133 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__inv_2
XFILLER_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_96 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07730_ rf\[24\]\[31\] rf\[25\]\[31\] rf\[26\]\[31\] rf\[27\]\[31\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__mux4_1
XFILLER_85_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05991_ _02839_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__clkbuf_1
X_08234__287 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__inv_2
X_08728__755 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__inv_2
XFILLER_65_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04942_ net48 net46 net47 VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__or3b_4
XFILLER_37_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07661_ rf\[8\]\[28\] rf\[9\]\[28\] rf\[10\]\[28\] rf\[11\]\[28\] _03691_ _03696_
+ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__mux4_2
X_04873_ _02258_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__clkbuf_1
X_07592_ _03579_ _04069_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__or2_1
X_09400_ net498 _01372_ VGND VGND VPWR VPWR rf\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_06612_ rf\[0\]\[26\] VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__clkbuf_1
X_09331_ net429 _01303_ VGND VGND VPWR VPWR rf\[17\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06543_ _03125_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06474_ rf\[11\]\[30\] net34 _03088_ VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__mux2_1
X_09262_ net360 _01234_ VGND VGND VPWR VPWR rf\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_05425_ _02546_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__clkbuf_1
X_09193_ net291 _01165_ VGND VGND VPWR VPWR rf\[12\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_05356_ _02510_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__clkbuf_1
XFILLER_107_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05287_ _02474_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07026_ _03524_ _03526_ _03528_ _03530_ _03216_ VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__a221o_1
X_08588__623 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__inv_2
X_08094__155 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__inv_2
XFILLER_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07928_ _04374_ _04379_ _04388_ _03220_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__o211a_1
X_07859_ _03211_ _04322_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__or2_1
XFILLER_44_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09529_ net627 _01501_ VGND VGND VPWR VPWR rf\[23\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08521__559 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__inv_2
XFILLER_61_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_108 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_158 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08381__427 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__inv_2
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06190_ rf\[16\]\[6\] _02102_ _02916_ VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__mux2_1
X_05210_ _02048_ rf\[30\]\[31\] _02434_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__mux2_1
X_05141_ _02224_ _02295_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__nor2_4
XFILLER_116_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05072_ _02362_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__clkbuf_1
X_09880_ net978 _01852_ VGND VGND VPWR VPWR rf\[10\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05974_ rf\[1\]\[15\] _02084_ _02814_ VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__mux2_1
X_04925_ _02286_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__clkbuf_1
X_07713_ rf\[4\]\[30\] rf\[5\]\[30\] rf\[6\]\[30\] rf\[7\]\[30\] _03599_ _03600_ VGND
+ VGND VPWR VPWR _04185_ sky130_fd_sc_hd__mux4_1
XFILLER_93_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_626 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07644_ rf\[12\]\[27\] rf\[13\]\[27\] rf\[14\]\[27\] rf\[15\]\[27\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__mux4_1
X_04856_ rf\[5\]\[8\] _02098_ _02226_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__mux2_1
XFILLER_41_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04787_ _02213_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__clkbuf_1
XFILLER_13_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07575_ _03603_ _04053_ _03682_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__o21a_1
X_09314_ net412 _01286_ VGND VGND VPWR VPWR rf\[16\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_06526_ rf\[11\]\[4\] net37 _03087_ VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__mux2_1
XFILLER_34_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06457_ _03080_ VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09245_ net343 _01217_ VGND VGND VPWR VPWR rf\[14\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_05408_ _02050_ _02536_ VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__nand2_4
X_09176_ net274 _01148_ VGND VGND VPWR VPWR rf\[12\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_06388_ _03044_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05339_ _02500_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__clkbuf_1
XFILLER_107_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput58 net58 VGND VGND VPWR VPWR port1_data_o[18] sky130_fd_sc_hd__buf_6
XFILLER_122_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07009_ _03206_ _03514_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__or2_1
Xoutput69 net69 VGND VGND VPWR VPWR port1_data_o[28] sky130_fd_sc_hd__buf_2
XFILLER_103_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10020_ net1118 _01992_ VGND VGND VPWR VPWR rf\[19\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08217__271 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__inv_2
XFILLER_56_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_570 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_659 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04710_ rf\[19\]\[13\] _02088_ _02154_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__mux2_1
X_05690_ _02684_ VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__clkbuf_1
X_04641_ rf\[3\]\[14\] _02086_ _02119_ VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__mux2_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_467 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04572_ _02095_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_16_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07360_ rf\[4\]\[12\] rf\[5\]\[12\] rf\[6\]\[12\] rf\[7\]\[12\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03850_ sky130_fd_sc_hd__mux4_2
X_08504__543 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__inv_2
X_06311_ _02090_ rf\[14\]\[12\] _02985_ VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__mux2_1
X_09066__14 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__inv_2
XFILLER_31_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07291_ _03778_ _03780_ _03782_ _03784_ _03608_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__a221o_1
X_06242_ _02969_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__clkbuf_1
X_06173_ _02933_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__clkbuf_1
X_05124_ _02389_ VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05055_ rf\[7\]\[9\] _02096_ _02331_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__mux2_1
X_09932_ net1030 _01904_ VGND VGND VPWR VPWR rf\[6\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09863_ net961 _01835_ VGND VGND VPWR VPWR rf\[7\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09794_ net892 _01766_ VGND VGND VPWR VPWR rf\[9\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05957_ _02822_ VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__clkbuf_1
X_05888_ rf\[20\]\[25\] _02064_ _02780_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__mux2_1
XTAP_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04908_ rf\[6\]\[16\] _02082_ _02262_ VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__mux2_1
XTAP_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08364__411 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__inv_2
X_04839_ _02241_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__clkbuf_1
X_07627_ _03699_ _04102_ _03682_ VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__o21a_1
X_07558_ _03629_ _04037_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__or2_1
X_06509_ _03107_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__clkbuf_1
XFILLER_42_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07489_ _03629_ _03971_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__or2_1
XFILLER_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09228_ net326 _01200_ VGND VGND VPWR VPWR rf\[13\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09159_ net257 _01131_ VGND VGND VPWR VPWR rf\[11\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10003_ net1101 _01975_ VGND VGND VPWR VPWR rf\[19\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_17_412 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08527__565 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__inv_2
XFILLER_32_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06860_ rf\[28\]\[20\] rf\[29\]\[20\] rf\[30\]\[20\] rf\[31\]\[20\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__mux4_1
X_05811_ _02054_ rf\[21\]\[30\] _02745_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__mux2_1
XFILLER_95_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08387__433 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__inv_2
X_06791_ rf\[24\]\[17\] rf\[25\]\[17\] rf\[26\]\[17\] rf\[27\]\[17\] _03198_ _03193_
+ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__mux4_1
X_05742_ _02710_ VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__clkbuf_16
XFILLER_82_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05673_ _02674_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__clkbuf_1
X_04624_ _02128_ VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__clkbuf_1
X_07412_ rf\[0\]\[15\] rf\[1\]\[15\] rf\[2\]\[15\] rf\[3\]\[15\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03899_ sky130_fd_sc_hd__mux4_2
X_07343_ rf\[20\]\[11\] rf\[21\]\[11\] rf\[22\]\[11\] rf\[23\]\[11\] _03662_ _03605_
+ VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__mux4_2
X_04555_ net17 VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__buf_12
X_07274_ rf\[20\]\[8\] rf\[21\]\[8\] rf\[22\]\[8\] rf\[23\]\[8\] _03582_ _03626_ VGND
+ VGND VPWR VPWR _03768_ sky130_fd_sc_hd__mux4_2
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09013_ clknet_1_1__leaf__04443_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__buf_1
X_06225_ _02070_ rf\[15\]\[22\] _02951_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__mux2_1
X_08320__369 clknet_1_1__leaf__04463_ VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__inv_2
X_06156_ rf\[16\]\[23\] _02068_ _02916_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__mux2_1
X_06087_ _02889_ VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__clkbuf_1
X_05107_ rf\[8\]\[16\] _02082_ _02365_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__mux2_1
X_09915_ net1013 _01887_ VGND VGND VPWR VPWR rf\[6\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_05038_ _02345_ VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__clkbuf_1
XFILLER_98_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09846_ net944 _01818_ VGND VGND VPWR VPWR rf\[7\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06989_ rf\[16\]\[27\] rf\[17\]\[27\] rf\[18\]\[27\] rf\[19\]\[27\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__mux4_1
X_09777_ net875 _01749_ VGND VGND VPWR VPWR rf\[9\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08860__879 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__inv_2
XFILLER_42_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08975__988 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1100 sky130_fd_sc_hd__inv_2
XFILLER_10_632 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08180__237 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__inv_2
XFILLER_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08256__308 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__inv_2
XFILLER_111_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_654 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09036__39 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__inv_2
X_06010_ rf\[18\]\[30\] _02054_ _02848_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__mux2_1
XFILLER_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07961_ rf\[12\]\[11\] rf\[13\]\[11\] rf\[14\]\[11\] rf\[15\]\[11\] _03251_ _03244_
+ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__mux4_1
XFILLER_114_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09700_ net798 _01672_ VGND VGND VPWR VPWR rf\[28\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04496_ clknet_0__04496_ VGND VGND VPWR VPWR clknet_1_1__leaf__04496_
+ sky130_fd_sc_hd__clkbuf_16
X_06912_ _03206_ _03422_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__or2_1
XFILLER_114_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07892_ rf\[8\]\[8\] rf\[9\]\[8\] rf\[10\]\[8\] rf\[11\]\[8\] _03262_ _03268_ VGND
+ VGND VPWR VPWR _04354_ sky130_fd_sc_hd__mux4_2
X_09631_ net729 _01603_ VGND VGND VPWR VPWR rf\[26\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_06843_ _03351_ _03353_ _03355_ _03357_ _03231_ VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__a221o_1
XFILLER_68_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09562_ net660 _01534_ VGND VGND VPWR VPWR rf\[24\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06774_ rf\[8\]\[16\] rf\[9\]\[16\] rf\[10\]\[16\] rf\[11\]\[16\] _03212_ _03213_
+ VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__mux4_1
X_05725_ _02100_ rf\[23\]\[7\] _02677_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__mux2_1
XFILLER_82_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09493_ net591 _01465_ VGND VGND VPWR VPWR rf\[22\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08820__841 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__inv_2
X_05656_ rf\[24\]\[8\] _02098_ _02642_ VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__mux2_1
XFILLER_23_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05587_ _02096_ rf\[25\]\[9\] _02607_ VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__mux2_1
X_04607_ rf\[3\]\[31\] _02048_ _02119_ VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__mux2_1
X_07326_ rf\[24\]\[10\] rf\[25\]\[10\] rf\[26\]\[10\] rf\[27\]\[10\] _03630_ _03613_
+ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__mux4_2
X_04538_ _02072_ rf\[31\]\[21\] _02052_ VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__mux2_1
X_08935__950 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1062 sky130_fd_sc_hd__inv_2
X_07257_ _03598_ _03751_ VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__or2_1
XFILLER_124_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06208_ _02952_ VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_3_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07188_ _03580_ _03686_ _03597_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__o21a_1
XFILLER_117_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06139_ _02915_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__buf_12
XFILLER_120_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09050__53 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__inv_2
XFILLER_59_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09829_ net927 _01801_ VGND VGND VPWR VPWR rf\[8\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_134 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08303__353 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__inv_2
XFILLER_13_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0__04450_ _04450_ VGND VGND VPWR VPWR clknet_0__04450_ sky130_fd_sc_hd__clkbuf_16
XFILLER_64_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08843__863 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__inv_2
XFILLER_18_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05510_ _02086_ rf\[26\]\[14\] _02572_ VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__mux2_1
X_06490_ rf\[11\]\[22\] net25 _03088_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__mux2_1
X_05441_ _02554_ VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__clkbuf_1
X_08958__972 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1084 sky130_fd_sc_hd__inv_2
X_08163__221 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__inv_2
X_05372_ _02518_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__clkbuf_1
X_07111_ _03584_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__buf_12
XFILLER_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07042_ rf\[12\]\[30\] rf\[13\]\[30\] rf\[14\]\[30\] rf\[15\]\[30\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__mux4_1
XFILLER_125_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_537 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08993_ clknet_1_0__leaf__04490_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__buf_1
XFILLER_87_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07944_ rf\[28\]\[10\] rf\[29\]\[10\] rf\[30\]\[10\] rf\[31\]\[10\] _03207_ _03208_
+ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04479_ clknet_0__04479_ VGND VGND VPWR VPWR clknet_1_1__leaf__04479_
+ sky130_fd_sc_hd__clkbuf_16
X_07875_ rf\[24\]\[7\] rf\[25\]\[7\] rf\[26\]\[7\] rf\[27\]\[7\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _04338_ sky130_fd_sc_hd__mux4_1
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09614_ net712 _01586_ VGND VGND VPWR VPWR rf\[26\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_06826_ rf\[0\]\[19\] rf\[1\]\[19\] rf\[2\]\[19\] rf\[3\]\[19\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03341_ sky130_fd_sc_hd__mux4_1
XFILLER_55_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09545_ net643 _01517_ VGND VGND VPWR VPWR rf\[23\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06757_ rf\[16\]\[15\] rf\[17\]\[15\] rf\[18\]\[15\] rf\[19\]\[15\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__mux4_1
XFILLER_71_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09476_ net574 _01448_ VGND VGND VPWR VPWR rf\[21\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_05708_ _02693_ VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__clkbuf_1
X_06688_ rf\[12\]\[13\] rf\[13\]\[13\] rf\[14\]\[13\] rf\[15\]\[13\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__mux4_1
X_05639_ _02657_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__clkbuf_1
X_08326__375 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__inv_2
XFILLER_51_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07309_ _03699_ _03801_ _03693_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__o21a_1
XFILLER_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08866__885 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__inv_2
XFILLER_74_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08186__243 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__inv_2
XTAP_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04499_ clknet_0__04499_ VGND VGND VPWR VPWR clknet_1_0__leaf__04499_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_24_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0__04502_ _04502_ VGND VGND VPWR VPWR clknet_0__04502_ sky130_fd_sc_hd__clkbuf_16
X_05990_ rf\[1\]\[7\] _02100_ _02814_ VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__mux2_1
X_04941_ _02294_ VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__clkbuf_1
XFILLER_93_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04872_ rf\[5\]\[0\] _02114_ _02225_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__mux2_1
XFILLER_37_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07660_ _03587_ _04133_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__or2_1
X_07591_ rf\[16\]\[24\] rf\[17\]\[24\] rf\[18\]\[24\] rf\[19\]\[24\] _03582_ _03631_
+ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__mux4_1
X_06611_ _03159_ VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__clkbuf_1
X_09330_ net428 _01302_ VGND VGND VPWR VPWR rf\[17\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_08349__397 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__inv_2
X_06542_ _02056_ rf\[29\]\[29\] _03122_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__mux2_1
XFILLER_61_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09261_ net359 _01233_ VGND VGND VPWR VPWR rf\[14\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_06473_ _03089_ VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__clkbuf_1
X_05424_ _02066_ rf\[27\]\[24\] _02538_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__mux2_1
X_09192_ net290 _01164_ VGND VGND VPWR VPWR rf\[12\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_05355_ _02064_ rf\[28\]\[25\] _02503_ VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__mux2_1
XFILLER_119_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08774__798 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__inv_2
X_05286_ rf\[2\]\[26\] _02062_ _02468_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__mux2_1
X_07025_ _03271_ _03529_ _03273_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__o21a_1
XFILLER_121_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08055__118 clknet_1_1__leaf__04449_ VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__inv_2
XFILLER_29_36 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07927_ _04381_ _04383_ _04385_ _04387_ _03231_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__a221o_1
XFILLER_28_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07858_ rf\[8\]\[6\] rf\[9\]\[6\] rf\[10\]\[6\] rf\[11\]\[6\] _03212_ _03221_ VGND
+ VGND VPWR VPWR _04322_ sky130_fd_sc_hd__mux4_1
X_07789_ rf\[28\]\[2\] rf\[29\]\[2\] rf\[30\]\[2\] rf\[31\]\[2\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _04257_ sky130_fd_sc_hd__mux4_1
XFILLER_28_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06809_ _03261_ _03324_ _03265_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__o21a_1
XFILLER_45_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09528_ net626 _01500_ VGND VGND VPWR VPWR rf\[23\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_468 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09459_ net557 _01431_ VGND VGND VPWR VPWR rf\[21\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_61_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05140_ _02397_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08734__760 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__inv_2
X_05071_ rf\[7\]\[1\] _02112_ _02330_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__mux2_1
XFILLER_112_610 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05973_ _02830_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__clkbuf_1
XTAP_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08692_ clknet_1_0__leaf__04479_ VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__buf_1
X_07712_ _03629_ _04183_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__or2_1
X_04924_ rf\[6\]\[8\] _02098_ _02262_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__mux2_1
XFILLER_81_711 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07643_ _03580_ _04115_ _04117_ _03595_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__o211a_1
XFILLER_26_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04855_ _02249_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__clkbuf_1
X_09313_ net411 _01285_ VGND VGND VPWR VPWR rf\[16\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_04786_ rf\[4\]\[9\] _02096_ _02190_ VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__mux2_1
X_07574_ rf\[0\]\[23\] rf\[1\]\[23\] rf\[2\]\[23\] rf\[3\]\[23\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _04053_ sky130_fd_sc_hd__mux4_1
X_06525_ _03115_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__clkbuf_1
X_06456_ rf\[12\]\[6\] _02102_ _03054_ VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__mux2_1
X_09244_ net342 _01216_ VGND VGND VPWR VPWR rf\[14\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_05407_ net46 net47 net48 VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__and3b_4
X_09175_ net273 _01147_ VGND VGND VPWR VPWR rf\[12\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06387_ _02100_ rf\[13\]\[7\] _03019_ VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__mux2_1
XFILLER_119_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05338_ rf\[2\]\[0\] _02114_ _02467_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__mux2_1
X_05269_ _02464_ VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__clkbuf_1
X_08102__163 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__inv_2
X_07008_ rf\[12\]\[28\] rf\[13\]\[28\] rf\[14\]\[28\] rf\[15\]\[28\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__mux4_2
Xoutput59 net59 VGND VGND VPWR VPWR port1_data_o[19] sky130_fd_sc_hd__buf_2
XFILLER_102_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08642__673 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__inv_2
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_325 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08757__782 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__inv_2
XFILLER_125_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08038__102 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__inv_2
XFILLER_79_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10079_ net115 _01027_ VGND VGND VPWR VPWR rf\[31\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_479 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04640_ _02136_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__clkbuf_1
X_04571_ _02094_ rf\[31\]\[10\] _02052_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__mux2_1
XFILLER_16_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07290_ _03588_ _03783_ _03595_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__o21a_1
X_06310_ _03004_ VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__clkbuf_1
X_06241_ _02086_ rf\[15\]\[14\] _02951_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__mux2_1
XFILLER_31_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06172_ rf\[16\]\[15\] _02084_ _02916_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__mux2_1
X_08125__185 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__inv_2
X_05123_ rf\[8\]\[8\] _02098_ _02365_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__mux2_1
X_05054_ _02353_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__clkbuf_1
X_09931_ net1029 _01903_ VGND VGND VPWR VPWR rf\[6\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_09862_ net960 _01834_ VGND VGND VPWR VPWR rf\[7\]\[24\] sky130_fd_sc_hd__dfxtp_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08813_ clknet_1_1__leaf__04490_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__buf_1
X_09793_ net891 _01765_ VGND VGND VPWR VPWR rf\[9\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05956_ rf\[1\]\[24\] _02066_ _02814_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__mux2_1
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04907_ _02277_ VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05887_ _02786_ VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__clkbuf_1
X_08665__695 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__inv_2
XTAP_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04838_ rf\[5\]\[17\] _02080_ _02226_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__mux2_1
X_07626_ rf\[4\]\[26\] rf\[5\]\[26\] rf\[6\]\[26\] rf\[7\]\[26\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _04102_ sky130_fd_sc_hd__mux4_2
XFILLER_41_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07557_ rf\[24\]\[22\] rf\[25\]\[22\] rf\[26\]\[22\] rf\[27\]\[22\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__mux4_1
XFILLER_41_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04769_ _02204_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__clkbuf_1
X_06508_ rf\[11\]\[13\] net15 _03088_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__mux2_1
XFILLER_22_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07488_ rf\[16\]\[19\] rf\[17\]\[19\] rf\[18\]\[19\] rf\[19\]\[19\] _03639_ _03631_
+ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__mux4_1
X_06439_ _03071_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__clkbuf_1
X_09227_ net325 _01199_ VGND VGND VPWR VPWR rf\[13\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09158_ net256 _01130_ VGND VGND VPWR VPWR rf\[11\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09089_ net187 _01061_ VGND VGND VPWR VPWR rf\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_08109_ clknet_1_0__leaf__04446_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__buf_1
XFILLER_123_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08025__90 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__inv_2
XFILLER_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10002_ net1100 _01974_ VGND VGND VPWR VPWR rf\[19\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08952__967 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1079 sky130_fd_sc_hd__inv_2
XFILLER_99_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_302 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05810_ _02746_ VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__clkbuf_1
XFILLER_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06790_ _03242_ _03306_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__or2_1
XFILLER_82_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05741_ _02432_ _02675_ VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__nand2_4
XFILLER_94_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05672_ rf\[24\]\[0\] _02114_ _02641_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__mux2_1
XFILLER_63_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07411_ _03579_ _03897_ _03693_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__o21a_1
X_04623_ rf\[3\]\[23\] _02068_ _02119_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__mux2_1
X_07342_ _03629_ _03832_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__or2_1
X_04554_ _02083_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__clkbuf_1
X_07273_ _03753_ _03758_ _03767_ _03650_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__o211a_1
X_06224_ _02960_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__clkbuf_1
X_06155_ _02924_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__clkbuf_1
X_08888__906 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1018 sky130_fd_sc_hd__inv_2
XFILLER_105_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05106_ _02380_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__clkbuf_1
X_06086_ rf\[17\]\[25\] _02064_ _02882_ VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__mux2_1
X_09914_ net1012 _01886_ VGND VGND VPWR VPWR rf\[6\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_05037_ rf\[7\]\[18\] _02078_ _02331_ VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__mux2_1
XFILLER_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09845_ net943 _01817_ VGND VGND VPWR VPWR rf\[7\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09776_ net874 _01748_ VGND VGND VPWR VPWR rf\[9\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06988_ _03205_ _03492_ _03494_ _03216_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__a31o_1
X_05939_ _02812_ VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__clkbuf_1
XTAP_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07609_ _03595_ _04079_ _04081_ _04083_ _04085_ VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__a32o_1
XFILLER_54_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_615 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08533__570 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__inv_2
XFILLER_103_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08796__819 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__inv_2
XFILLER_33_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07960_ _03211_ _04418_ _03273_ VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__o21a_1
XFILLER_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04495_ clknet_0__04495_ VGND VGND VPWR VPWR clknet_1_1__leaf__04495_
+ sky130_fd_sc_hd__clkbuf_16
X_06911_ rf\[4\]\[23\] rf\[5\]\[23\] rf\[6\]\[23\] rf\[7\]\[23\] _03243_ _03244_ VGND
+ VGND VPWR VPWR _03422_ sky130_fd_sc_hd__mux4_1
XFILLER_67_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07891_ _03195_ _04352_ VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__or2_1
X_08004__71 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__inv_2
X_09630_ net728 _01602_ VGND VGND VPWR VPWR rf\[26\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_06842_ _03196_ _03356_ _03205_ VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__o21a_1
X_09561_ net659 _01533_ VGND VGND VPWR VPWR rf\[24\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_06773_ _03206_ _03290_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__or2_1
XFILLER_36_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05724_ _02701_ VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09492_ net590 _01464_ VGND VGND VPWR VPWR rf\[22\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05655_ _02665_ VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__clkbuf_1
X_05586_ _02629_ VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__clkbuf_1
X_04606_ _02118_ VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__buf_12
XFILLER_23_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07325_ _03598_ _03816_ _03682_ VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__o21a_1
X_04537_ net24 VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__buf_12
XFILLER_109_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08441__483 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__inv_2
X_07256_ rf\[4\]\[7\] rf\[5\]\[7\] rf\[6\]\[7\] rf\[7\]\[7\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03751_ sky130_fd_sc_hd__mux4_1
XFILLER_31_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06207_ _02048_ rf\[15\]\[31\] _02951_ VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__mux2_1
X_07187_ rf\[8\]\[3\] rf\[9\]\[3\] rf\[10\]\[3\] rf\[11\]\[3\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _03686_ sky130_fd_sc_hd__mux4_1
XFILLER_117_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08556__592 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__inv_2
X_06138_ _02152_ _02188_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__nor2_4
XFILLER_3_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_579 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06069_ _02879_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__clkbuf_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09828_ net926 _01800_ VGND VGND VPWR VPWR rf\[8\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09759_ net857 _01731_ VGND VGND VPWR VPWR rf\[30\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05440_ _02082_ rf\[27\]\[16\] _02538_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__mux2_1
X_08919__935 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1047 sky130_fd_sc_hd__inv_2
X_05371_ _02080_ rf\[28\]\[17\] _02503_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__mux2_1
XFILLER_118_104 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07110_ _03611_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__buf_4
X_07041_ _03188_ _03542_ _03544_ _03203_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__o211a_1
XFILLER_125_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_549 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04478_ clknet_0__04478_ VGND VGND VPWR VPWR clknet_1_1__leaf__04478_
+ sky130_fd_sc_hd__clkbuf_16
X_07943_ _03242_ _04402_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__or2_1
X_07874_ _03242_ _04336_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__or2_1
X_06825_ _03340_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_6
X_09613_ net711 _01585_ VGND VGND VPWR VPWR rf\[25\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_327 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09544_ net642 _01516_ VGND VGND VPWR VPWR rf\[23\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_08779__803 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__inv_2
X_06756_ _03260_ _03266_ _03270_ _03274_ _03216_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__a221o_1
X_09475_ net573 _01447_ VGND VGND VPWR VPWR rf\[21\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_05707_ _02082_ rf\[23\]\[16\] _02677_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__mux2_1
X_06687_ _03192_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__buf_12
XFILLER_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05638_ rf\[24\]\[17\] _02080_ _02642_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__mux2_1
X_05569_ _02078_ rf\[25\]\[18\] _02607_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__mux2_1
X_07308_ rf\[28\]\[9\] rf\[29\]\[9\] rf\[30\]\[9\] rf\[31\]\[9\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _03801_ sky130_fd_sc_hd__mux4_1
X_07239_ rf\[0\]\[6\] rf\[1\]\[6\] rf\[2\]\[6\] rf\[3\]\[6\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03735_ sky130_fd_sc_hd__mux4_2
XFILLER_118_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08751__777 clknet_1_1__leaf__04486_ VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__inv_2
XFILLER_78_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08827__848 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__inv_2
XFILLER_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08147__206 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__inv_2
XFILLER_91_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04498_ clknet_0__04498_ VGND VGND VPWR VPWR clknet_1_0__leaf__04498_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08572__607 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__inv_2
XFILLER_115_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0__04501_ _04501_ VGND VGND VPWR VPWR clknet_0__04501_ sky130_fd_sc_hd__clkbuf_16
XFILLER_97_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08687__716 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__inv_2
XFILLER_97_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04940_ rf\[6\]\[0\] _02114_ _02261_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__mux2_1
X_04871_ _02257_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__clkbuf_1
X_06610_ rf\[0\]\[27\] VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07590_ _03597_ _04065_ _04067_ _03608_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__a31o_1
XFILLER_92_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06541_ _03124_ VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__clkbuf_1
XFILLER_80_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06472_ rf\[11\]\[31\] net35 _03088_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__mux2_1
X_09260_ net358 _01232_ VGND VGND VPWR VPWR rf\[14\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_05423_ _02545_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09191_ net289 _01163_ VGND VGND VPWR VPWR rf\[12\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_05354_ _02509_ VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__clkbuf_1
X_05285_ _02473_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__clkbuf_1
X_07024_ rf\[4\]\[29\] rf\[5\]\[29\] rf\[6\]\[29\] rf\[7\]\[29\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _03529_ sky130_fd_sc_hd__mux4_1
XFILLER_115_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07926_ _03196_ _04386_ _03265_ VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__o21a_1
XFILLER_29_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09020__24 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__inv_2
XFILLER_110_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08332__380 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__inv_2
X_07857_ _03206_ _04320_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__or2_1
X_07788_ _03261_ _04255_ VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__or2_1
XFILLER_56_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06808_ rf\[8\]\[18\] rf\[9\]\[18\] rf\[10\]\[18\] rf\[11\]\[18\] _03262_ _03268_
+ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__mux4_2
X_09527_ net625 _01499_ VGND VGND VPWR VPWR rf\[23\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_06739_ _03236_ _03241_ _03257_ _03258_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__o211a_1
XFILLER_43_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_672 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09458_ net556 _01430_ VGND VGND VPWR VPWR rf\[21\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08595__629 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__inv_2
X_09389_ net487 _01361_ VGND VGND VPWR VPWR rf\[18\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_10 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08240__293 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__inv_2
X_05070_ _02361_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__clkbuf_1
XFILLER_97_300 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_622 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05972_ rf\[1\]\[16\] _02082_ _02814_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__mux2_1
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07711_ rf\[0\]\[30\] rf\[1\]\[30\] rf\[2\]\[30\] rf\[3\]\[30\] _03630_ _03613_ VGND
+ VGND VPWR VPWR _04183_ sky130_fd_sc_hd__mux4_1
X_04923_ _02285_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04854_ rf\[5\]\[9\] _02096_ _02226_ VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__mux2_1
XFILLER_38_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07642_ _03598_ _04116_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__or2_1
X_09312_ net410 _01284_ VGND VGND VPWR VPWR rf\[16\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_04785_ _02212_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__clkbuf_1
X_07573_ _03625_ _04051_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__or2_1
X_06524_ rf\[11\]\[5\] net38 _03087_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__mux2_1
XFILLER_61_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06455_ _03079_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__clkbuf_1
X_09243_ net341 _01215_ VGND VGND VPWR VPWR rf\[14\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_05406_ _02535_ VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__clkbuf_1
X_09174_ net272 _01146_ VGND VGND VPWR VPWR rf\[12\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_06386_ _03043_ VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__clkbuf_1
X_05337_ _02499_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__clkbuf_1
XFILLER_107_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05268_ _02110_ rf\[30\]\[2\] _02433_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__mux2_1
Xoutput49 net49 VGND VGND VPWR VPWR port1_data_o[0] sky130_fd_sc_hd__buf_2
X_07007_ _03203_ _03506_ _03508_ _03510_ _03512_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__a32o_1
XFILLER_88_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05199_ rf\[9\]\[3\] _02108_ _02398_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__mux2_1
XFILLER_102_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07909_ _04370_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_1
XFILLER_72_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08718__745 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__inv_2
XFILLER_106_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_336 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10078_ net114 _01026_ VGND VGND VPWR VPWR rf\[31\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_08463__504 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__inv_2
XFILLER_47_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04570_ net12 VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__buf_12
X_08578__613 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__inv_2
XFILLER_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06240_ _02968_ VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_163 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06171_ _02932_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__clkbuf_1
X_05122_ _02388_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__clkbuf_1
X_05053_ rf\[7\]\[10\] _02094_ _02331_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__mux2_1
X_09930_ net1028 _01902_ VGND VGND VPWR VPWR rf\[6\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09861_ net959 _01833_ VGND VGND VPWR VPWR rf\[7\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_08550__587 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__inv_2
X_08812_ clknet_1_0__leaf__04443_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__buf_1
X_09792_ net890 _01764_ VGND VGND VPWR VPWR rf\[9\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05955_ _02821_ VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__clkbuf_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04906_ rf\[6\]\[17\] _02080_ _02262_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__mux2_1
X_05886_ rf\[20\]\[26\] _02062_ _02780_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__mux2_1
X_08626__658 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__inv_2
XFILLER_81_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04837_ _02240_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__clkbuf_1
X_07625_ _03579_ _04100_ VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__or2_1
X_07556_ _03598_ _04035_ _03682_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__o21a_1
XFILLER_41_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04768_ rf\[4\]\[18\] _02078_ _02190_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__mux2_1
X_06507_ _03106_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__clkbuf_1
X_07487_ _03699_ _03969_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__or2_1
X_04699_ _02167_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__clkbuf_1
X_09226_ net324 _01198_ VGND VGND VPWR VPWR rf\[13\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06438_ rf\[12\]\[15\] _02084_ _03054_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__mux2_1
XFILLER_108_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09157_ net255 _01129_ VGND VGND VPWR VPWR rf\[11\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_06369_ _02082_ rf\[13\]\[16\] _03019_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__mux2_1
X_09088_ net186 _01060_ VGND VGND VPWR VPWR rf\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08371__417 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__inv_2
XFILLER_88_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10001_ net1099 _01973_ VGND VGND VPWR VPWR rf\[19\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_08486__526 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__inv_2
XFILLER_91_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_520 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05740_ _02709_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__clkbuf_1
X_05671_ _02673_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_564 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08390_ clknet_1_1__leaf__04457_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__buf_1
X_08131__190 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__inv_2
X_07410_ rf\[8\]\[15\] rf\[9\]\[15\] rf\[10\]\[15\] rf\[11\]\[15\] _03691_ _03696_
+ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__mux4_1
X_04622_ _02127_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__clkbuf_1
X_07341_ rf\[16\]\[11\] rf\[17\]\[11\] rf\[18\]\[11\] rf\[19\]\[11\] _03639_ _03631_
+ VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__mux4_1
X_04553_ _02082_ rf\[31\]\[16\] _02052_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__mux2_1
XFILLER_35_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07272_ _03760_ _03762_ _03764_ _03766_ _03623_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__a221o_2
XFILLER_31_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06223_ _02068_ rf\[15\]\[23\] _02951_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__mux2_1
XFILLER_12_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08394__439 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__inv_2
X_06154_ rf\[16\]\[24\] _02066_ _02916_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__mux2_1
X_05105_ rf\[8\]\[17\] _02080_ _02365_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__mux2_1
X_06085_ _02888_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09913_ net1011 _01885_ VGND VGND VPWR VPWR rf\[6\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_05036_ _02344_ VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__clkbuf_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09844_ net942 _01816_ VGND VGND VPWR VPWR rf\[7\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06987_ _03211_ _03493_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__or2_1
X_09775_ net873 _01747_ VGND VGND VPWR VPWR rf\[9\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_05938_ rf\[20\]\[0\] _02114_ _02779_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__mux2_1
X_05869_ _02112_ rf\[21\]\[1\] _02744_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__mux2_1
XTAP_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07608_ _03588_ _04084_ _03597_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__o21a_1
XFILLER_54_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07539_ _03629_ _04019_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__or2_1
XFILLER_10_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_627 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09209_ net307 _01181_ VGND VGND VPWR VPWR rf\[13\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_51 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_689 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08354__401 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__inv_2
XFILLER_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04494_ clknet_0__04494_ VGND VGND VPWR VPWR clknet_1_1__leaf__04494_
+ sky130_fd_sc_hd__clkbuf_16
X_06910_ _03203_ _03414_ _03416_ _03418_ _03420_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__a32o_1
X_08469__510 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__inv_2
X_07890_ rf\[12\]\[8\] rf\[13\]\[8\] rf\[14\]\[8\] rf\[15\]\[8\] _03197_ _03192_ VGND
+ VGND VPWR VPWR _04352_ sky130_fd_sc_hd__mux4_2
X_06841_ rf\[28\]\[19\] rf\[29\]\[19\] rf\[30\]\[19\] rf\[31\]\[19\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__mux4_1
X_09560_ net658 _01532_ VGND VGND VPWR VPWR rf\[24\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06772_ rf\[12\]\[16\] rf\[13\]\[16\] rf\[14\]\[16\] rf\[15\]\[16\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__mux4_1
X_08511_ clknet_1_0__leaf__04468_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__buf_1
X_05723_ _02098_ rf\[23\]\[8\] _02677_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__mux2_1
X_09491_ net589 _01463_ VGND VGND VPWR VPWR rf\[22\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05654_ rf\[24\]\[9\] _02096_ _02642_ VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__mux2_1
XFILLER_63_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08894__911 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1023 sky130_fd_sc_hd__inv_2
X_05585_ _02094_ rf\[25\]\[10\] _02607_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__mux2_1
X_04605_ _02116_ _02117_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__nor2_4
XFILLER_51_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07324_ rf\[20\]\[10\] rf\[21\]\[10\] rf\[22\]\[10\] rf\[23\]\[10\] _03662_ _03605_
+ VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__mux4_1
X_04536_ _02071_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__clkbuf_1
X_07255_ rf\[0\]\[7\] rf\[1\]\[7\] rf\[2\]\[7\] rf\[3\]\[7\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03750_ sky130_fd_sc_hd__mux4_1
X_06206_ _02950_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__buf_12
XFILLER_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07186_ _03625_ _03684_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__or2_1
X_08517__555 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__inv_2
X_06137_ _02914_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__clkbuf_1
X_06068_ rf\[18\]\[1\] _02112_ _02847_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__mux2_1
X_05019_ rf\[7\]\[27\] _02060_ _02331_ VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__mux2_1
X_09827_ net925 _01799_ VGND VGND VPWR VPWR rf\[8\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09758_ net856 _01730_ VGND VGND VPWR VPWR rf\[30\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08981__994 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1106 sky130_fd_sc_hd__inv_2
XFILLER_46_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08010__75 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__inv_2
XTAP_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09689_ net787 _01661_ VGND VGND VPWR VPWR rf\[28\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08262__314 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__inv_2
XFILLER_14_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08377__423 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__inv_2
XFILLER_10_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09026__30 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__inv_2
XFILLER_89_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09041__44 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__inv_2
XFILLER_36_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07993__60 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__inv_2
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_306 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08804__827 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__inv_2
XFILLER_18_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08425__468 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__inv_2
X_09055__3 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__inv_2
XFILLER_21_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05370_ _02517_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07040_ _03247_ _03543_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__or2_1
XFILLER_5_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04477_ clknet_0__04477_ VGND VGND VPWR VPWR clknet_1_1__leaf__04477_
+ sky130_fd_sc_hd__clkbuf_16
X_07942_ rf\[24\]\[10\] rf\[25\]\[10\] rf\[26\]\[10\] rf\[27\]\[10\] _03251_ _03244_
+ VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__mux4_2
X_07873_ rf\[16\]\[7\] rf\[17\]\[7\] rf\[18\]\[7\] rf\[19\]\[7\] _03243_ _03244_ VGND
+ VGND VPWR VPWR _04336_ sky130_fd_sc_hd__mux4_1
XFILLER_68_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08170__227 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__inv_2
X_09612_ net710 _01584_ VGND VGND VPWR VPWR rf\[25\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_06824_ _03220_ _03330_ _03339_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__and3_4
XFILLER_83_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09543_ net641 _01515_ VGND VGND VPWR VPWR rf\[23\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08285__336 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__inv_2
X_06755_ _03271_ _03272_ _03273_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__o21a_1
X_09474_ net572 _01446_ VGND VGND VPWR VPWR rf\[21\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_05706_ _02692_ VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__clkbuf_1
X_06686_ _03189_ VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__buf_12
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05637_ _02656_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__clkbuf_1
XFILLER_11_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05568_ _02620_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__clkbuf_1
X_07307_ _03579_ _03799_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__or2_1
X_05499_ _02584_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__clkbuf_1
X_04519_ net30 VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__buf_12
X_07238_ _03579_ _03733_ _03693_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__o21a_1
X_07169_ _03661_ _03664_ _03666_ _03668_ _03623_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__a221o_1
XFILLER_105_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04497_ clknet_0__04497_ VGND VGND VPWR VPWR clknet_1_0__leaf__04497_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_30_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0__04500_ _04500_ VGND VGND VPWR VPWR clknet_0__04500_ sky130_fd_sc_hd__clkbuf_16
XFILLER_123_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08193__249 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__inv_2
XFILLER_123_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_548 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_412 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04870_ rf\[5\]\[1\] _02112_ _02225_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__mux2_1
XFILLER_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06540_ _02054_ rf\[29\]\[30\] _03122_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__mux2_1
X_06471_ _03087_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__clkbuf_16
X_05422_ _02064_ rf\[27\]\[25\] _02538_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__mux2_1
XFILLER_60_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08210_ clknet_1_0__leaf__04457_ VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__buf_1
XFILLER_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09190_ net288 _01162_ VGND VGND VPWR VPWR rf\[12\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_05353_ _02062_ rf\[28\]\[26\] _02503_ VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__mux2_1
X_05284_ rf\[2\]\[27\] _02060_ _02468_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__mux2_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07023_ _03261_ _03527_ VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__or2_1
XFILLER_115_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07925_ rf\[28\]\[9\] rf\[29\]\[9\] rf\[30\]\[9\] rf\[31\]\[9\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04386_ sky130_fd_sc_hd__mux4_1
X_09007__1019 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1131 sky130_fd_sc_hd__inv_2
XFILLER_29_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07856_ rf\[12\]\[6\] rf\[13\]\[6\] rf\[14\]\[6\] rf\[15\]\[6\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04320_ sky130_fd_sc_hd__mux4_1
X_07787_ rf\[24\]\[2\] rf\[25\]\[2\] rf\[26\]\[2\] rf\[27\]\[2\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04255_ sky130_fd_sc_hd__mux4_1
X_04999_ rf\[10\]\[4\] _02106_ _02296_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__mux2_1
X_06807_ _03195_ _03322_ VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__or2_4
XFILLER_44_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09526_ net624 _01498_ VGND VGND VPWR VPWR rf\[23\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_06738_ _03220_ VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__buf_6
X_09457_ net555 _01429_ VGND VGND VPWR VPWR rf\[21\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06669_ _03189_ VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__buf_12
XFILLER_52_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09388_ net486 _01360_ VGND VGND VPWR VPWR rf\[18\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_117_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08872__891 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net1003 sky130_fd_sc_hd__inv_2
XFILLER_86_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08153__211 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__inv_2
XFILLER_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08268__320 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__inv_2
XFILLER_28_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08693__721 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__inv_2
XFILLER_112_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_312 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08316__365 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__inv_2
XFILLER_2_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05971_ _02829_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__clkbuf_1
X_07710_ _03603_ _04181_ _03693_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__o21a_1
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04922_ rf\[6\]\[9\] _02096_ _02262_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__mux2_1
XFILLER_93_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04853_ _02248_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__clkbuf_1
X_07641_ rf\[4\]\[27\] rf\[5\]\[27\] rf\[6\]\[27\] rf\[7\]\[27\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _04116_ sky130_fd_sc_hd__mux4_1
X_07572_ rf\[4\]\[23\] rf\[5\]\[23\] rf\[6\]\[23\] rf\[7\]\[23\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _04051_ sky130_fd_sc_hd__mux4_2
X_09311_ net409 _01283_ VGND VGND VPWR VPWR rf\[16\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_04784_ rf\[4\]\[10\] _02094_ _02190_ VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__mux2_1
X_06523_ _03114_ VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__clkbuf_1
X_06454_ rf\[12\]\[7\] _02100_ _03054_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__mux2_1
XFILLER_33_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09242_ net340 _01214_ VGND VGND VPWR VPWR rf\[14\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_05405_ _02114_ rf\[28\]\[0\] _02502_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__mux2_1
X_09173_ net271 _01145_ VGND VGND VPWR VPWR rf\[12\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_06385_ _02098_ rf\[13\]\[8\] _03019_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__mux2_1
X_08856__875 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__inv_2
XFILLER_119_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05336_ rf\[2\]\[1\] _02112_ _02467_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__mux2_1
X_08061__124 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__inv_2
X_05267_ _02463_ VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__clkbuf_1
X_07006_ _03196_ _03511_ _03205_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__o21a_1
X_05198_ _02427_ VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__clkbuf_1
X_08176__233 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__inv_2
XFILLER_57_710 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07908_ _03220_ _04360_ _04369_ VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__and3_1
XFILLER_72_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07839_ _03271_ _04303_ _03273_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__o21a_1
XFILLER_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09509_ net607 _01481_ VGND VGND VPWR VPWR rf\[22\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_08603__637 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__inv_2
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08224__278 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__inv_2
XFILLER_125_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_409 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08339__387 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__inv_2
XFILLER_121_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_76 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10077_ net113 _01025_ VGND VGND VPWR VPWR rf\[31\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_702 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_598 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08879__897 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1009 sky130_fd_sc_hd__inv_2
XFILLER_31_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08084__146 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__inv_2
XFILLER_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09006__1018 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1130 sky130_fd_sc_hd__inv_2
XFILLER_7_30 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06170_ rf\[16\]\[16\] _02082_ _02916_ VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__mux2_1
X_05121_ rf\[8\]\[9\] _02096_ _02365_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__mux2_1
XFILLER_7_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08199__255 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__inv_2
XFILLER_116_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05052_ _02352_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__clkbuf_1
XFILLER_98_610 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09860_ net958 _01832_ VGND VGND VPWR VPWR rf\[7\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09791_ net889 _01763_ VGND VGND VPWR VPWR rf\[9\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05954_ rf\[1\]\[25\] _02064_ _02814_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__mux2_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04905_ _02276_ VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__clkbuf_1
X_05885_ _02785_ VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07624_ rf\[0\]\[26\] rf\[1\]\[26\] rf\[2\]\[26\] rf\[3\]\[26\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _04100_ sky130_fd_sc_hd__mux4_2
XTAP_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04836_ rf\[5\]\[18\] _02078_ _02226_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__mux2_1
X_07555_ rf\[20\]\[22\] rf\[21\]\[22\] rf\[22\]\[22\] rf\[23\]\[22\] _03662_ _03605_
+ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__mux4_1
X_04767_ _02203_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__clkbuf_1
X_07486_ rf\[20\]\[19\] rf\[21\]\[19\] rf\[22\]\[19\] rf\[23\]\[19\] _03582_ _03626_
+ VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__mux4_2
X_06506_ rf\[11\]\[14\] net16 _03088_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__mux2_1
X_04698_ rf\[19\]\[19\] _02076_ _02154_ VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__mux2_1
X_06437_ _03070_ VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09225_ net323 _01197_ VGND VGND VPWR VPWR rf\[13\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_09156_ net254 _01128_ VGND VGND VPWR VPWR rf\[11\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_06368_ _03034_ VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__clkbuf_1
XFILLER_108_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05319_ _02490_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__clkbuf_1
X_06299_ _02078_ rf\[14\]\[18\] _02985_ VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__mux2_1
X_09087_ net185 _01059_ VGND VGND VPWR VPWR rf\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10000_ net1098 _01972_ VGND VGND VPWR VPWR rf\[19\]\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_88_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09989_ net1087 _01961_ VGND VGND VPWR VPWR rf\[4\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_29_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_50 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_470 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08016__81 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__inv_2
XFILLER_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08031__95 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__inv_2
XFILLER_35_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05670_ rf\[24\]\[1\] _02112_ _02641_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__mux2_1
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04621_ rf\[3\]\[24\] _02066_ _02119_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__mux2_1
XFILLER_51_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04552_ net18 VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__buf_12
XFILLER_16_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07340_ _03597_ _03828_ _03830_ _03608_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__a31o_1
X_07271_ _03588_ _03765_ _03597_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__o21a_1
X_06222_ _02959_ VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__clkbuf_1
X_09047__50 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__inv_2
X_06153_ _02923_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05104_ _02379_ VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__clkbuf_1
XFILLER_105_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06084_ rf\[17\]\[26\] _02062_ _02882_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__mux2_1
X_09912_ net1010 _01884_ VGND VGND VPWR VPWR rf\[6\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_05035_ rf\[7\]\[19\] _02076_ _02331_ VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__mux2_1
XFILLER_98_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09843_ net941 _01815_ VGND VGND VPWR VPWR rf\[7\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06986_ rf\[8\]\[27\] rf\[9\]\[27\] rf\[10\]\[27\] rf\[11\]\[27\] _03212_ _03221_
+ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__mux4_1
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09774_ net872 _01746_ VGND VGND VPWR VPWR rf\[9\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_05937_ _02811_ VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__clkbuf_1
XTAP_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05868_ _02775_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07607_ rf\[28\]\[25\] rf\[29\]\[25\] rf\[30\]\[25\] rf\[31\]\[25\] _03583_ _03585_
+ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__mux4_2
X_04819_ _02231_ VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__clkbuf_1
X_05799_ _02108_ rf\[22\]\[3\] _02710_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__mux2_1
X_07538_ rf\[24\]\[21\] rf\[25\]\[21\] rf\[26\]\[21\] rf\[27\]\[21\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__mux4_1
X_08067__130 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__inv_2
XFILLER_41_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07469_ _03598_ _03952_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__or2_1
XFILLER_10_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09208_ net306 _01180_ VGND VGND VPWR VPWR rf\[13\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09139_ net237 _01111_ VGND VGND VPWR VPWR rf\[11\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_08492__531 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__inv_2
XFILLER_118_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_627 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09005__1017 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1129 sky130_fd_sc_hd__inv_2
XFILLER_18_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08609__643 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__inv_2
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08115__175 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__inv_2
XFILLER_33_705 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08655__685 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04493_ clknet_0__04493_ VGND VGND VPWR VPWR clknet_1_1__leaf__04493_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_4_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06840_ _03211_ _03354_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__or2_1
XFILLER_95_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06771_ _03188_ _03286_ _03288_ _03203_ VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__o211a_1
X_05722_ _02700_ VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__clkbuf_1
X_09490_ net588 _01462_ VGND VGND VPWR VPWR rf\[22\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_05653_ _02664_ VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__clkbuf_1
X_04604_ net48 net47 net46 VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__or3_4
X_05584_ _02628_ VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__clkbuf_1
X_07323_ _03629_ _03814_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__or2_1
X_04535_ _02070_ rf\[31\]\[22\] _02052_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__mux2_1
X_08402__447 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__inv_2
X_07254_ _03749_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
X_06205_ _02050_ _02949_ VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__nand2_4
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07185_ rf\[12\]\[3\] rf\[13\]\[3\] rf\[14\]\[3\] rf\[15\]\[3\] _03604_ _03613_ VGND
+ VGND VPWR VPWR _03684_ sky130_fd_sc_hd__mux4_1
X_06136_ rf\[17\]\[0\] _02114_ _02881_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__mux2_1
XFILLER_105_548 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06067_ _02878_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__clkbuf_1
X_05018_ _02335_ VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__clkbuf_1
XFILLER_101_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09826_ net924 _01798_ VGND VGND VPWR VPWR rf\[8\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_08138__197 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__inv_2
XFILLER_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09757_ net855 _01729_ VGND VGND VPWR VPWR rf\[30\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_06969_ rf\[16\]\[26\] rf\[17\]\[26\] rf\[18\]\[26\] rf\[19\]\[26\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__mux4_1
XFILLER_74_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08942__957 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1069 sky130_fd_sc_hd__inv_2
XTAP_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09688_ net786 _01660_ VGND VGND VPWR VPWR rf\[28\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_15_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_608 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04476_ clknet_0__04476_ VGND VGND VPWR VPWR clknet_1_1__leaf__04476_
+ sky130_fd_sc_hd__clkbuf_16
X_07941_ _03247_ _04400_ _03273_ VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__o21a_1
X_08965__979 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1091 sky130_fd_sc_hd__inv_2
X_07872_ _03271_ _04334_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__or2_1
X_09611_ net709 _01583_ VGND VGND VPWR VPWR rf\[25\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06823_ _03332_ _03334_ _03336_ _03338_ _03231_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__a221o_1
XFILLER_55_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09542_ net640 _01514_ VGND VGND VPWR VPWR rf\[23\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_06754_ _03202_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__buf_12
XFILLER_83_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05705_ _02080_ rf\[23\]\[17\] _02677_ VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__mux2_1
XFILLER_71_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09473_ net571 _01445_ VGND VGND VPWR VPWR rf\[21\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_06685_ _03195_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__buf_8
X_05636_ rf\[24\]\[18\] _02078_ _02642_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__mux2_1
XFILLER_24_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05567_ _02076_ rf\[25\]\[19\] _02607_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__mux2_1
X_07306_ rf\[24\]\[9\] rf\[25\]\[9\] rf\[26\]\[9\] rf\[27\]\[9\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03799_ sky130_fd_sc_hd__mux4_1
X_04518_ _02059_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__clkbuf_1
X_05498_ _02074_ rf\[26\]\[20\] _02572_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__mux2_1
XFILLER_119_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09004__1016 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1128 sky130_fd_sc_hd__inv_2
X_07237_ rf\[8\]\[6\] rf\[9\]\[6\] rf\[10\]\[6\] rf\[11\]\[6\] _03691_ _03696_ VGND
+ VGND VPWR VPWR _03733_ sky130_fd_sc_hd__mux4_1
XFILLER_124_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07168_ _03588_ _03667_ _03597_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__o21a_1
X_06119_ _02905_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__clkbuf_1
X_07099_ rf\[12\]\[0\] rf\[13\]\[0\] rf\[14\]\[0\] rf\[15\]\[0\] _03599_ _03600_ VGND
+ VGND VPWR VPWR _03601_ sky130_fd_sc_hd__mux4_1
XFILLER_105_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09809_ net907 _01781_ VGND VGND VPWR VPWR rf\[8\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_67 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_663 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04496_ clknet_0__04496_ VGND VGND VPWR VPWR clknet_1_0__leaf__04496_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08925__941 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1053 sky130_fd_sc_hd__inv_2
XFILLER_65_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06470_ _02116_ _02295_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__nor2_4
X_05421_ _02544_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05352_ _02508_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__clkbuf_1
X_05283_ _02472_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__clkbuf_1
X_08670__700 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__inv_2
X_07022_ rf\[0\]\[29\] rf\[1\]\[29\] rf\[2\]\[29\] rf\[3\]\[29\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _03527_ sky130_fd_sc_hd__mux4_1
XFILLER_115_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08291__341 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__inv_2
X_08973_ clknet_1_0__leaf__04490_ VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__buf_1
XFILLER_114_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04459_ clknet_0__04459_ VGND VGND VPWR VPWR clknet_1_1__leaf__04459_
+ sky130_fd_sc_hd__clkbuf_16
X_07924_ _03242_ _04384_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__or2_1
XFILLER_69_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07855_ _03188_ _04316_ _04318_ _03203_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__o211a_1
XFILLER_29_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07786_ _03271_ _04253_ _03202_ VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__o21a_1
X_04998_ _02324_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__clkbuf_1
X_06806_ rf\[12\]\[18\] rf\[13\]\[18\] rf\[14\]\[18\] rf\[15\]\[18\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__mux4_2
X_09525_ net623 _01497_ VGND VGND VPWR VPWR rf\[23\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_06737_ _03246_ _03250_ _03253_ _03256_ _03231_ VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__a221o_1
XFILLER_83_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06668_ net1 VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__buf_8
X_09456_ net554 _01428_ VGND VGND VPWR VPWR rf\[21\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_05619_ _02647_ VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__clkbuf_1
X_08408__453 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__inv_2
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09387_ net485 _01359_ VGND VGND VPWR VPWR rf\[18\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_06599_ _03153_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_571 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08454__495 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__inv_2
XFILLER_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08948__963 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1075 sky130_fd_sc_hd__inv_2
X_10093_ net129 _01041_ VGND VGND VPWR VPWR rf\[31\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04479_ clknet_0__04479_ VGND VGND VPWR VPWR clknet_1_0__leaf__04479_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08201__257 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__inv_2
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05970_ rf\[1\]\[17\] _02080_ _02814_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__mux2_1
X_04921_ _02284_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__clkbuf_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07640_ rf\[0\]\[27\] rf\[1\]\[27\] rf\[2\]\[27\] rf\[3\]\[27\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _04115_ sky130_fd_sc_hd__mux4_1
XFILLER_53_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_660 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04852_ rf\[5\]\[10\] _02094_ _02226_ VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__mux2_1
X_07571_ _03595_ _04043_ _04045_ _04047_ _04049_ VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__a32o_1
X_09003__1015 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1127 sky130_fd_sc_hd__inv_2
X_04783_ _02211_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__clkbuf_1
X_09310_ net408 _01282_ VGND VGND VPWR VPWR rf\[16\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_08741__767 clknet_1_1__leaf__04486_ VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__inv_2
X_06522_ rf\[11\]\[6\] net39 _03088_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__mux2_1
XFILLER_18_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06453_ _03078_ VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__clkbuf_1
X_09241_ net339 _01213_ VGND VGND VPWR VPWR rf\[14\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_05404_ _02534_ VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__clkbuf_1
X_09172_ net270 _01144_ VGND VGND VPWR VPWR rf\[12\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_06384_ _03042_ VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__clkbuf_1
X_05335_ _02498_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__clkbuf_1
X_08817__838 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__inv_2
X_07005_ rf\[28\]\[28\] rf\[29\]\[28\] rf\[30\]\[28\] rf\[31\]\[28\] _03191_ _03193_
+ VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__mux4_1
X_05266_ _02108_ rf\[30\]\[3\] _02433_ VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__mux2_1
X_05197_ rf\[9\]\[4\] _02106_ _02398_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__mux2_1
XFILLER_103_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07907_ _04362_ _04364_ _04366_ _04368_ _03230_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__a221o_1
XFILLER_57_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07838_ rf\[4\]\[5\] rf\[5\]\[5\] rf\[6\]\[5\] rf\[7\]\[5\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _04303_ sky130_fd_sc_hd__mux4_1
XFILLER_84_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09508_ net606 _01480_ VGND VGND VPWR VPWR rf\[22\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_07769_ _03206_ _04237_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__or2_1
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09439_ net537 _01411_ VGND VGND VPWR VPWR rf\[20\]\[17\] sky130_fd_sc_hd__dfxtp_1
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08677__706 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__inv_2
XFILLER_40_622 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10076_ net167 _01024_ VGND VGND VPWR VPWR rf\[31\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_714 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08764__789 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__inv_2
XFILLER_46_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08045__109 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__inv_2
XFILLER_117_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05120_ _02387_ VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__clkbuf_1
X_05051_ rf\[7\]\[11\] _02092_ _02331_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__mux2_1
XFILLER_98_622 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09790_ net888 _01762_ VGND VGND VPWR VPWR rf\[9\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05953_ _02820_ VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__clkbuf_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05884_ rf\[20\]\[27\] _02060_ _02780_ VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__mux2_1
X_08672_ clknet_1_1__leaf__04479_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__buf_1
X_04904_ rf\[6\]\[18\] _02078_ _02262_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__mux2_1
XFILLER_81_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07623_ _03579_ _04098_ net9 VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__o21a_1
XFILLER_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04835_ _02239_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_599 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07554_ _03579_ _04033_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__or2_1
X_04766_ rf\[4\]\[19\] _02076_ _02190_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__mux2_1
X_04697_ _02166_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__clkbuf_1
X_07485_ _03954_ _03959_ _03968_ _03650_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__o211a_1
X_06505_ _03105_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06436_ rf\[12\]\[16\] _02082_ _03054_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__mux2_1
X_09224_ net322 _01196_ VGND VGND VPWR VPWR rf\[13\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09155_ net253 _01127_ VGND VGND VPWR VPWR rf\[11\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_06367_ _02080_ rf\[13\]\[17\] _03019_ VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__mux2_1
X_09086_ net184 _01058_ VGND VGND VPWR VPWR rf\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_05318_ rf\[2\]\[10\] _02094_ _02468_ VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__mux2_1
X_06298_ _02998_ VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__clkbuf_1
X_05249_ _02454_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__clkbuf_1
XFILLER_122_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_526 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09988_ net1086 _01960_ VGND VGND VPWR VPWR rf\[4\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08724__751 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__inv_2
XFILLER_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09002__1014 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1126 sky130_fd_sc_hd__inv_2
X_10059_ net150 _02031_ VGND VGND VPWR VPWR rf\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_08090__151 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__inv_2
XFILLER_75_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04620_ _02126_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__clkbuf_1
X_04551_ _02081_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_92_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07270_ rf\[28\]\[7\] rf\[29\]\[7\] rf\[30\]\[7\] rf\[31\]\[7\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _03765_ sky130_fd_sc_hd__mux4_1
XFILLER_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06221_ _02066_ rf\[15\]\[24\] _02951_ VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__mux2_1
X_08207__263 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__inv_2
X_06152_ rf\[16\]\[25\] _02064_ _02916_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__mux2_1
XFILLER_8_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06083_ _02887_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__clkbuf_1
X_09062__10 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__inv_2
X_05103_ rf\[8\]\[18\] _02078_ _02365_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__mux2_1
X_09911_ net1009 _01883_ VGND VGND VPWR VPWR rf\[6\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_05034_ _02343_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__clkbuf_1
XFILLER_113_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09842_ net940 _01814_ VGND VGND VPWR VPWR rf\[7\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09773_ net871 _01745_ VGND VGND VPWR VPWR rf\[30\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_08747__773 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__inv_2
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06985_ _03206_ _03491_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__or2_1
X_05936_ rf\[20\]\[1\] _02112_ _02779_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__mux2_1
X_05867_ _02110_ rf\[21\]\[2\] _02744_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__mux2_1
XFILLER_54_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07606_ _03580_ _04082_ VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__or2_1
XFILLER_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04818_ rf\[5\]\[27\] _02060_ _02226_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__mux2_1
X_05798_ _02739_ VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__clkbuf_1
X_07537_ _03598_ _04017_ _03682_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__o21a_1
X_04749_ _02194_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__clkbuf_1
X_07468_ rf\[4\]\[18\] rf\[5\]\[18\] rf\[6\]\[18\] rf\[7\]\[18\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _03952_ sky130_fd_sc_hd__mux4_1
XFILLER_10_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09207_ net305 _01179_ VGND VGND VPWR VPWR rf\[13\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_07399_ _03625_ _03886_ VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__or2_1
X_06419_ _03061_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__clkbuf_1
X_09138_ net236 _01110_ VGND VGND VPWR VPWR rf\[11\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08540__577 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__inv_2
XFILLER_9_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08616__648 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__inv_2
XFILLER_5_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f__04492_ clknet_0__04492_ VGND VGND VPWR VPWR clknet_1_1__leaf__04492_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_4_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06770_ _03247_ _03287_ VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__or2_1
X_05721_ _02096_ rf\[23\]\[9\] _02677_ VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__mux2_1
XFILLER_82_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05652_ rf\[24\]\[10\] _02094_ _02642_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__mux2_1
XFILLER_91_650 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04603_ net45 net44 net43 VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__nand3_4
X_05583_ _02092_ rf\[25\]\[11\] _02607_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__mux2_1
X_07322_ rf\[16\]\[10\] rf\[17\]\[10\] rf\[18\]\[10\] rf\[19\]\[10\] _03639_ _03631_
+ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__mux4_1
X_04534_ net25 VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__buf_12
X_07253_ _03612_ _03739_ _03748_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__and3_4
X_08476__516 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__inv_2
X_06204_ net48 net47 net46 VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__and3b_2
X_07184_ _03603_ _03681_ _03682_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__o21a_1
XFILLER_117_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06135_ _02913_ VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__clkbuf_1
XFILLER_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06066_ rf\[18\]\[2\] _02110_ _02847_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__mux2_1
XFILLER_59_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05017_ rf\[7\]\[28\] _02058_ _02331_ VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__mux2_1
X_09825_ net923 _01797_ VGND VGND VPWR VPWR rf\[8\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09756_ net854 _01728_ VGND VGND VPWR VPWR rf\[30\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06968_ _03469_ _03471_ _03473_ _03475_ _03216_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__a221o_1
X_05919_ _02802_ VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__clkbuf_1
X_09687_ net785 _01659_ VGND VGND VPWR VPWR rf\[28\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06899_ _03196_ _03410_ _03265_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__o21a_1
X_09001__1013 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1125 sky130_fd_sc_hd__inv_2
XTAP_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08563__599 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__inv_2
XTAP_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_387 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08499__538 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__inv_2
XFILLER_13_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09017__21 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__inv_2
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07940_ rf\[20\]\[10\] rf\[21\]\[10\] rf\[22\]\[10\] rf\[23\]\[10\] _03212_ _03213_
+ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04475_ clknet_0__04475_ VGND VGND VPWR VPWR clknet_1_1__leaf__04475_
+ sky130_fd_sc_hd__clkbuf_16
X_07871_ rf\[20\]\[7\] rf\[21\]\[7\] rf\[22\]\[7\] rf\[23\]\[7\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _04334_ sky130_fd_sc_hd__mux4_1
XFILLER_68_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09610_ net708 _01582_ VGND VGND VPWR VPWR rf\[25\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06822_ _03271_ _03337_ _03265_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__o21a_1
XFILLER_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09541_ net639 _01513_ VGND VGND VPWR VPWR rf\[23\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06753_ rf\[4\]\[15\] rf\[5\]\[15\] rf\[6\]\[15\] rf\[7\]\[15\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _03272_ sky130_fd_sc_hd__mux4_2
X_05704_ _02691_ VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09472_ net570 _01444_ VGND VGND VPWR VPWR rf\[21\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06684_ net4 VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__buf_12
X_05635_ _02655_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08523__561 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__inv_2
X_05566_ _02619_ VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__clkbuf_1
X_04517_ _02058_ rf\[31\]\[28\] _02052_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__mux2_1
X_07305_ _03699_ _03797_ _03682_ VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__o21a_1
X_05497_ _02583_ VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__clkbuf_1
XFILLER_109_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07236_ _03587_ _03731_ VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__or2_1
XFILLER_117_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07167_ rf\[28\]\[2\] rf\[29\]\[2\] rf\[30\]\[2\] rf\[31\]\[2\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _03667_ sky130_fd_sc_hd__mux4_1
X_06118_ rf\[17\]\[9\] _02096_ _02882_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__mux2_1
XFILLER_3_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07098_ _03584_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__buf_12
XFILLER_59_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06049_ _02869_ VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__clkbuf_1
XFILLER_101_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09808_ net906 _01780_ VGND VGND VPWR VPWR rf\[8\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09739_ net837 _01711_ VGND VGND VPWR VPWR rf\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f__04495_ clknet_0__04495_ VGND VGND VPWR VPWR clknet_1_0__leaf__04495_
+ sky130_fd_sc_hd__clkbuf_16
X_08459__500 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__inv_2
XFILLER_24_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08810__833 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__inv_2
XFILLER_124_688 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08546__583 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__inv_2
X_05420_ _02062_ rf\[27\]\[26\] _02538_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__mux2_1
XTAP_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05351_ _02060_ rf\[28\]\[27\] _02503_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__mux2_1
XFILLER_119_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05282_ rf\[2\]\[28\] _02058_ _02468_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__mux2_1
X_07021_ _03261_ _03525_ net4 VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__o21a_1
XFILLER_114_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09000__1012 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1124 sky130_fd_sc_hd__inv_2
XFILLER_102_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07923_ rf\[24\]\[9\] rf\[25\]\[9\] rf\[26\]\[9\] rf\[27\]\[9\] _03251_ _03244_ VGND
+ VGND VPWR VPWR _04384_ sky130_fd_sc_hd__mux4_2
X_08252__304 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04458_ clknet_0__04458_ VGND VGND VPWR VPWR clknet_1_1__leaf__04458_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_84_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07854_ _03247_ _04317_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__or2_1
Xclkbuf_0__04489_ _04489_ VGND VGND VPWR VPWR clknet_0__04489_ sky130_fd_sc_hd__clkbuf_16
X_06805_ _03231_ _03312_ _03321_ _03258_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__o211a_1
X_07785_ rf\[20\]\[2\] rf\[21\]\[2\] rf\[22\]\[2\] rf\[23\]\[2\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04253_ sky130_fd_sc_hd__mux4_1
X_04997_ rf\[10\]\[5\] _02104_ _02296_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__mux2_1
XFILLER_44_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09524_ net622 _01496_ VGND VGND VPWR VPWR rf\[23\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_06736_ _03196_ _03255_ _03205_ VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__o21a_1
X_09455_ net553 _01427_ VGND VGND VPWR VPWR rf\[21\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_06667_ _03187_ VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__buf_12
XFILLER_24_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05618_ rf\[24\]\[27\] _02060_ _02642_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__mux2_1
XFILLER_52_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09386_ net484 _01358_ VGND VGND VPWR VPWR rf\[18\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06598_ _02112_ rf\[29\]\[1\] _03121_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__mux2_1
X_05549_ _02058_ rf\[25\]\[28\] _02607_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__mux2_1
XFILLER_20_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07219_ _03580_ _03713_ _03715_ _03595_ VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__o211a_1
XFILLER_105_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08415__458 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__inv_2
X_10092_ net128 _01040_ VGND VGND VPWR VPWR rf\[31\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_08909__926 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1038 sky130_fd_sc_hd__inv_2
XFILLER_120_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04478_ clknet_0__04478_ VGND VGND VPWR VPWR clknet_1_0__leaf__04478_
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08275__326 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__inv_2
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04920_ rf\[6\]\[10\] _02094_ _02262_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__mux2_1
XFILLER_93_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04851_ _02247_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__clkbuf_1
X_07570_ _03588_ _04048_ _03597_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__o21a_1
XFILLER_65_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04782_ rf\[4\]\[11\] _02092_ _02190_ VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__mux2_1
XFILLER_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06521_ _03113_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__clkbuf_1
X_09240_ net338 _01212_ VGND VGND VPWR VPWR rf\[14\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_06452_ rf\[12\]\[8\] _02098_ _03054_ VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__mux2_1
X_05403_ _02112_ rf\[28\]\[1\] _02502_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__mux2_1
X_09171_ net269 _01143_ VGND VGND VPWR VPWR rf\[12\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06383_ _02096_ rf\[13\]\[9\] _03019_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__mux2_1
X_05334_ rf\[2\]\[2\] _02110_ _02467_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__mux2_1
X_07004_ _03188_ _03509_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__or2_1
X_05265_ _02462_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__clkbuf_1
X_05196_ _02426_ VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__clkbuf_1
XFILLER_88_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07906_ _03271_ _04367_ _03265_ VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__o21a_1
XFILLER_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07837_ _03261_ _04301_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__or2_1
XFILLER_72_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07768_ rf\[12\]\[1\] rf\[13\]\[1\] rf\[14\]\[1\] rf\[15\]\[1\] _03251_ _03221_ VGND
+ VGND VPWR VPWR _04237_ sky130_fd_sc_hd__mux4_1
X_09507_ net605 _01479_ VGND VGND VPWR VPWR rf\[22\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06719_ rf\[8\]\[14\] rf\[9\]\[14\] rf\[10\]\[14\] rf\[11\]\[14\] _03212_ _03213_
+ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__mux4_1
X_07699_ _03699_ _04170_ VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__or2_1
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09438_ net536 _01410_ VGND VGND VPWR VPWR rf\[20\]\[16\] sky130_fd_sc_hd__dfxtp_1
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09369_ net467 _01341_ VGND VGND VPWR VPWR rf\[18\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08298__348 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__inv_2
XFILLER_125_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10075_ net166 _02047_ VGND VGND VPWR VPWR rf\[31\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_631 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08322__371 clknet_1_1__leaf__04463_ VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__inv_2
XFILLER_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05050_ _02351_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__clkbuf_1
XFILLER_98_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05952_ rf\[1\]\[26\] _02062_ _02814_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__mux2_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05883_ _02784_ VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__clkbuf_1
XFILLER_78_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04903_ _02275_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__clkbuf_1
XFILLER_54_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08862__881 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__inv_2
X_04834_ rf\[5\]\[19\] _02076_ _02226_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__mux2_1
X_07622_ rf\[8\]\[26\] rf\[9\]\[26\] rf\[10\]\[26\] rf\[11\]\[26\] _03691_ _03696_
+ VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__mux4_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_491 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07553_ rf\[16\]\[22\] rf\[17\]\[22\] rf\[18\]\[22\] rf\[19\]\[22\] _03639_ _03631_
+ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__mux4_1
X_04765_ _02202_ VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__clkbuf_1
X_07484_ _03961_ _03963_ _03965_ _03967_ _03623_ VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__a221o_1
X_04696_ rf\[19\]\[20\] _02074_ _02154_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__mux2_1
X_08977__990 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1102 sky130_fd_sc_hd__inv_2
X_06504_ rf\[11\]\[15\] net17 _03088_ VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__mux2_1
XFILLER_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_623 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06435_ _03069_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__clkbuf_1
XFILLER_42_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09223_ net321 _01195_ VGND VGND VPWR VPWR rf\[13\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_09154_ net252 _01126_ VGND VGND VPWR VPWR rf\[11\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_06366_ _03033_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__clkbuf_1
X_09085_ net183 _01057_ VGND VGND VPWR VPWR rf\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_05317_ _02489_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__clkbuf_1
X_06297_ _02076_ rf\[14\]\[19\] _02985_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__mux2_1
XFILLER_123_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05248_ _02090_ rf\[30\]\[12\] _02434_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__mux2_1
X_08258__310 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__inv_2
XFILLER_1_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05179_ rf\[9\]\[13\] _02088_ _02399_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__mux2_1
XFILLER_1_538 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09987_ net1085 _01959_ VGND VGND VPWR VPWR rf\[4\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08345__393 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__inv_2
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10058_ net149 _02030_ VGND VGND VPWR VPWR rf\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08051__114 clknet_1_1__leaf__04449_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__inv_2
XFILLER_51_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04550_ _02080_ rf\[31\]\[17\] _02052_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__mux2_1
XFILLER_50_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06220_ _02958_ VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06151_ _02922_ VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__clkbuf_1
XFILLER_105_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06082_ rf\[17\]\[27\] _02060_ _02882_ VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__mux2_1
XFILLER_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05102_ _02378_ VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__clkbuf_1
X_09910_ net1008 _01882_ VGND VGND VPWR VPWR rf\[6\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_05033_ rf\[7\]\[20\] _02074_ _02331_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__mux2_1
XFILLER_98_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09841_ net939 _01813_ VGND VGND VPWR VPWR rf\[7\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09772_ net870 _01744_ VGND VGND VPWR VPWR rf\[30\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06984_ rf\[12\]\[27\] rf\[13\]\[27\] rf\[14\]\[27\] rf\[15\]\[27\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__mux4_1
X_05935_ _02810_ VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__clkbuf_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08708__736 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__inv_2
XFILLER_54_512 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08214__268 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__inv_2
X_05866_ _02774_ VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__clkbuf_1
XFILLER_54_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07605_ rf\[24\]\[25\] rf\[25\]\[25\] rf\[26\]\[25\] rf\[27\]\[25\] _03590_ _03591_
+ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__mux4_1
XTAP_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05797_ _02106_ rf\[22\]\[4\] _02710_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__mux2_1
X_04817_ _02230_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__clkbuf_1
X_07536_ rf\[20\]\[21\] rf\[21\]\[21\] rf\[22\]\[21\] rf\[23\]\[21\] _03662_ _03605_
+ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__mux4_1
X_04748_ rf\[4\]\[28\] _02058_ _02190_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__mux2_1
X_07467_ rf\[0\]\[18\] rf\[1\]\[18\] rf\[2\]\[18\] rf\[3\]\[18\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03951_ sky130_fd_sc_hd__mux4_1
X_04679_ _02157_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__clkbuf_1
XFILLER_10_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09206_ net304 _01178_ VGND VGND VPWR VPWR rf\[13\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_07398_ rf\[4\]\[14\] rf\[5\]\[14\] rf\[6\]\[14\] rf\[7\]\[14\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03886_ sky130_fd_sc_hd__mux4_2
X_06418_ rf\[12\]\[25\] _02064_ _03054_ VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__mux2_1
X_09038__41 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__inv_2
X_09137_ net235 _01109_ VGND VGND VPWR VPWR rf\[11\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06349_ _02062_ rf\[13\]\[26\] _03019_ VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__mux2_1
XFILLER_78_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08568__604 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__inv_2
X_08074__136 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__inv_2
XFILLER_49_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04491_ clknet_0__04491_ VGND VGND VPWR VPWR clknet_1_1__leaf__04491_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05720_ _02699_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__clkbuf_1
X_05651_ _02663_ VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__clkbuf_1
XFILLER_91_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08370_ clknet_1_1__leaf__04457_ VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__buf_1
X_04602_ _02115_ VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05582_ _02627_ VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__clkbuf_1
X_08361__408 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__inv_2
XFILLER_16_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07321_ _03597_ _03810_ _03812_ _03608_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__a31o_1
X_04533_ _02069_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__clkbuf_1
X_07252_ _03741_ _03743_ _03745_ _03747_ _03623_ VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__a221o_1
X_07183_ _03594_ VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__clkbuf_16
X_06203_ _02948_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__clkbuf_1
X_06134_ rf\[17\]\[1\] _02112_ _02881_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__mux2_1
X_06065_ _02877_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__clkbuf_1
X_08097__158 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__inv_2
X_05016_ _02334_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__clkbuf_1
XFILLER_86_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09824_ net922 _01796_ VGND VGND VPWR VPWR rf\[8\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09755_ net853 _01727_ VGND VGND VPWR VPWR rf\[30\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06967_ _03271_ _03474_ _03273_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__o21a_1
XFILLER_104_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05918_ rf\[20\]\[10\] _02094_ _02780_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__mux2_1
X_09686_ net784 _01658_ VGND VGND VPWR VPWR rf\[28\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_06898_ rf\[28\]\[22\] rf\[29\]\[22\] rf\[30\]\[22\] rf\[31\]\[22\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__mux4_1
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05849_ _02092_ rf\[21\]\[11\] _02745_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__mux2_1
XTAP_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07519_ _03579_ _04000_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__or2_1
XFILLER_10_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_20 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_399 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08121__181 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__inv_2
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08661__691 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__inv_2
XFILLER_9_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09032__36 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04474_ clknet_0__04474_ VGND VGND VPWR VPWR clknet_1_1__leaf__04474_
+ sky130_fd_sc_hd__clkbuf_16
X_08057__120 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__inv_2
X_07870_ _04319_ _04324_ _04333_ _03258_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__o211a_1
X_06821_ rf\[28\]\[18\] rf\[29\]\[18\] rf\[30\]\[18\] rf\[31\]\[18\] _03262_ _03263_
+ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__mux4_1
XFILLER_28_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09540_ net638 _01512_ VGND VGND VPWR VPWR rf\[23\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_06752_ _03195_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__clkbuf_16
X_09471_ net569 _01443_ VGND VGND VPWR VPWR rf\[21\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_05703_ _02078_ rf\[23\]\[18\] _02677_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__mux2_1
XFILLER_48_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06683_ _03188_ _03194_ _03201_ _03203_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__o211a_1
X_05634_ rf\[24\]\[19\] _02076_ _02642_ VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__mux2_1
XFILLER_51_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05565_ _02074_ rf\[25\]\[20\] _02607_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__mux2_1
X_07304_ rf\[20\]\[9\] rf\[21\]\[9\] rf\[22\]\[9\] rf\[23\]\[9\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03797_ sky130_fd_sc_hd__mux4_2
X_04516_ net31 VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__buf_12
X_05496_ _02072_ rf\[26\]\[21\] _02572_ VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__mux2_1
X_07235_ rf\[12\]\[6\] rf\[13\]\[6\] rf\[14\]\[6\] rf\[15\]\[6\] _03589_ _03584_ VGND
+ VGND VPWR VPWR _03731_ sky130_fd_sc_hd__mux4_1
XFILLER_50_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_631 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07166_ _03603_ _03665_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__or2_1
XFILLER_117_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06117_ _02904_ VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07097_ _03581_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__buf_12
XFILLER_78_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06048_ rf\[18\]\[11\] _02092_ _02848_ VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__mux2_1
XFILLER_59_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09807_ net905 _01779_ VGND VGND VPWR VPWR rf\[8\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09738_ net836 _01710_ VGND VGND VPWR VPWR rf\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_09669_ net767 _01641_ VGND VGND VPWR VPWR rf\[27\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_548 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04494_ clknet_0__04494_ VGND VGND VPWR VPWR clknet_1_0__leaf__04494_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08884__902 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1014 sky130_fd_sc_hd__inv_2
XFILLER_37_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08507__546 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__inv_2
XFILLER_61_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05350_ _02507_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05281_ _02471_ VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__clkbuf_1
X_08971__985 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1097 sky130_fd_sc_hd__inv_2
XFILLER_115_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07020_ rf\[8\]\[29\] rf\[9\]\[29\] rf\[10\]\[29\] rf\[11\]\[29\] _03262_ _03268_
+ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__mux4_1
XFILLER_69_710 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07922_ _03247_ _04382_ _03273_ VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__o21a_1
Xclkbuf_1_1__f__04457_ clknet_0__04457_ VGND VGND VPWR VPWR clknet_1_1__leaf__04457_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_68_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04488_ _04488_ VGND VGND VPWR VPWR clknet_0__04488_ sky130_fd_sc_hd__clkbuf_16
X_07853_ rf\[4\]\[6\] rf\[5\]\[6\] rf\[6\]\[6\] rf\[7\]\[6\] _03254_ _03199_ VGND
+ VGND VPWR VPWR _04317_ sky130_fd_sc_hd__mux4_1
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06804_ _03314_ _03316_ _03318_ _03320_ _03216_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__a221o_1
X_08367__414 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__inv_2
X_07784_ _03187_ _04251_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__or2_1
X_04996_ _02323_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__clkbuf_1
XFILLER_45_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09523_ net621 _01495_ VGND VGND VPWR VPWR rf\[23\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06735_ rf\[28\]\[14\] rf\[29\]\[14\] rf\[30\]\[14\] rf\[31\]\[14\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__mux4_1
XFILLER_64_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_695 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09454_ net552 _01426_ VGND VGND VPWR VPWR rf\[21\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_06666_ net3 VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__buf_6
XFILLER_52_621 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05617_ _02646_ VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__clkbuf_1
X_09385_ net483 _01357_ VGND VGND VPWR VPWR rf\[18\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06597_ _03152_ VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05548_ _02610_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__clkbuf_1
X_05479_ _02574_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__clkbuf_1
X_07218_ _03598_ _03714_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__or2_1
X_07149_ _03612_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__buf_6
XFILLER_106_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10091_ net127 _01039_ VGND VGND VPWR VPWR rf\[31\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f__04477_ clknet_0__04477_ VGND VGND VPWR VPWR clknet_1_0__leaf__04477_
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08955__969 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1081 sky130_fd_sc_hd__inv_2
X_08160__218 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__inv_2
XFILLER_11_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04850_ rf\[5\]\[11\] _02092_ _02226_ VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__mux2_1
XFILLER_81_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04781_ _02210_ VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__clkbuf_1
XFILLER_19_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06520_ rf\[11\]\[7\] net40 _03088_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__mux2_1
X_09069__17 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__inv_2
X_06451_ _03077_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__clkbuf_1
XFILLER_34_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05402_ _02533_ VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__clkbuf_1
X_09170_ net268 _01142_ VGND VGND VPWR VPWR rf\[12\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_06382_ _03041_ VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05333_ _02497_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__clkbuf_1
X_05264_ _02106_ rf\[30\]\[4\] _02433_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__mux2_1
X_07003_ rf\[24\]\[28\] rf\[25\]\[28\] rf\[26\]\[28\] rf\[27\]\[28\] _03198_ _03193_
+ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__mux4_1
XFILLER_115_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05195_ rf\[9\]\[5\] _02104_ _02398_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__mux2_1
XFILLER_115_486 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07905_ rf\[28\]\[8\] rf\[29\]\[8\] rf\[30\]\[8\] rf\[31\]\[8\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _04367_ sky130_fd_sc_hd__mux4_1
XFILLER_69_584 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07836_ rf\[0\]\[5\] rf\[1\]\[5\] rf\[2\]\[5\] rf\[3\]\[5\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04301_ sky130_fd_sc_hd__mux4_2
X_04979_ rf\[10\]\[14\] _02086_ _02297_ VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__mux2_1
X_07767_ _03211_ _04235_ _03273_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__o21a_1
X_09506_ net604 _01478_ VGND VGND VPWR VPWR rf\[22\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06718_ _03206_ _03237_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__or2_1
X_07698_ rf\[20\]\[30\] rf\[21\]\[30\] rf\[22\]\[30\] rf\[23\]\[30\] _03582_ _03626_
+ VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__mux4_2
XFILLER_72_49 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09437_ net535 _01409_ VGND VGND VPWR VPWR rf\[20\]\[15\] sky130_fd_sc_hd__dfxtp_1
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06649_ _03178_ VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__clkbuf_1
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09368_ net466 _01340_ VGND VGND VPWR VPWR rf\[18\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_09299_ net397 _01271_ VGND VGND VPWR VPWR rf\[16\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_08915__931 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1043 sky130_fd_sc_hd__inv_2
XFILLER_125_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10074_ net165 _02046_ VGND VGND VPWR VPWR rf\[31\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_62_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05951_ _02819_ VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__clkbuf_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05882_ rf\[20\]\[28\] _02058_ _02780_ VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__mux2_1
X_04902_ rf\[6\]\[19\] _02076_ _02262_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__mux2_1
XFILLER_38_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04833_ _02238_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07621_ _03587_ _04096_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__or2_1
X_08823__844 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__inv_2
X_07552_ _03597_ _04029_ _04031_ _03608_ VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__a31o_1
X_06503_ _03104_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__clkbuf_1
X_04764_ rf\[4\]\[20\] _02074_ _02190_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__mux2_1
X_04695_ _02165_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__clkbuf_1
X_07483_ _03588_ _03966_ _03693_ VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__o21a_1
X_08938__953 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1065 sky130_fd_sc_hd__inv_2
X_06434_ rf\[12\]\[17\] _02080_ _03054_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__mux2_1
XFILLER_21_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09222_ net320 _01194_ VGND VGND VPWR VPWR rf\[13\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_09153_ net251 _01125_ VGND VGND VPWR VPWR rf\[11\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08143__202 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__inv_2
X_06365_ _02078_ rf\[13\]\[18\] _03019_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__mux2_1
X_05316_ rf\[2\]\[11\] _02092_ _02468_ VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__mux2_1
XFILLER_107_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09084_ net182 _01056_ VGND VGND VPWR VPWR rf\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_06296_ _02997_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__clkbuf_1
X_05247_ _02453_ VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__clkbuf_1
XFILLER_115_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05178_ _02417_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__clkbuf_1
XFILLER_89_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09986_ net1084 _01958_ VGND VGND VPWR VPWR rf\[4\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08683__712 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__inv_2
XFILLER_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07819_ rf\[8\]\[4\] rf\[9\]\[4\] rf\[10\]\[4\] rf\[11\]\[4\] _03212_ _03221_ VGND
+ VGND VPWR VPWR _04285_ sky130_fd_sc_hd__mux4_1
XFILLER_29_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08798__821 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__inv_2
XFILLER_13_624 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08306__356 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__inv_2
XFILLER_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_690 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08770__795 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__inv_2
XFILLER_106_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10057_ net148 _02029_ VGND VGND VPWR VPWR rf\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08846__866 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__inv_2
X_09058__6 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__inv_2
XFILLER_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08166__224 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__inv_2
XFILLER_16_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06150_ rf\[16\]\[26\] _02062_ _02916_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__mux2_1
X_06081_ _02886_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__clkbuf_1
X_05101_ rf\[8\]\[19\] _02076_ _02365_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__mux2_1
XFILLER_104_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05032_ _02342_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__clkbuf_1
XFILLER_113_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09840_ net938 _01812_ VGND VGND VPWR VPWR rf\[7\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09771_ net869 _01743_ VGND VGND VPWR VPWR rf\[30\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_06983_ _03188_ _03487_ _03489_ _03203_ VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__o211a_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05934_ rf\[20\]\[2\] _02110_ _02779_ VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__mux2_1
XFILLER_85_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08022__87 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__inv_2
XFILLER_27_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05865_ _02108_ rf\[21\]\[3\] _02744_ VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__mux2_1
XFILLER_94_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05796_ _02738_ VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__clkbuf_1
XTAP_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07604_ _03629_ _04080_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__or2_1
X_04816_ rf\[5\]\[28\] _02058_ _02226_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__mux2_1
X_07535_ _03579_ _04015_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__or2_1
X_08329__378 clknet_1_1__leaf__04463_ VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__inv_2
X_04747_ _02193_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__clkbuf_1
X_07466_ _03950_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_1
XFILLER_50_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04678_ rf\[19\]\[29\] _02056_ _02154_ VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__mux2_1
X_09205_ net303 _01177_ VGND VGND VPWR VPWR rf\[13\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_06417_ _03060_ VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__clkbuf_1
X_07397_ _03595_ _03878_ _03880_ _03882_ _03884_ VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__a32o_1
XFILLER_22_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09136_ net234 _01108_ VGND VGND VPWR VPWR rf\[11\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_06348_ _03024_ VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__clkbuf_1
X_08754__779 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__inv_2
X_06279_ _02058_ rf\[14\]\[28\] _02985_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__mux2_1
X_08869__888 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__inv_2
X_09969_ net1067 _01941_ VGND VGND VPWR VPWR rf\[4\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_549 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04490_ clknet_0__04490_ VGND VGND VPWR VPWR clknet_1_1__leaf__04490_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05650_ rf\[24\]\[11\] _02092_ _02642_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__mux2_1
XFILLER_84_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05581_ _02090_ rf\[25\]\[12\] _02607_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__mux2_1
XFILLER_91_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04601_ _02114_ rf\[31\]\[0\] _02051_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__mux2_1
XFILLER_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04532_ _02068_ rf\[31\]\[23\] _02052_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__mux2_1
X_07320_ _03603_ _03811_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__or2_1
X_07251_ _03699_ _03746_ _03693_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__o21a_1
X_07182_ rf\[0\]\[3\] rf\[1\]\[3\] rf\[2\]\[3\] rf\[3\]\[3\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _03681_ sky130_fd_sc_hd__mux4_2
X_06202_ rf\[16\]\[0\] _02114_ _02915_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__mux2_1
XFILLER_117_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06133_ _02912_ VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__clkbuf_1
X_08714__741 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__inv_2
X_06064_ rf\[18\]\[3\] _02108_ _02847_ VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__mux2_1
XFILLER_99_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05015_ rf\[7\]\[29\] _02056_ _02331_ VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__mux2_1
X_09823_ net921 _01795_ VGND VGND VPWR VPWR rf\[8\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08829__850 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__inv_2
X_09754_ net852 _01726_ VGND VGND VPWR VPWR rf\[30\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06966_ rf\[4\]\[26\] rf\[5\]\[26\] rf\[6\]\[26\] rf\[7\]\[26\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _03474_ sky130_fd_sc_hd__mux4_1
X_05917_ _02801_ VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__clkbuf_1
X_06897_ _03242_ _03408_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__or2_1
X_09685_ net783 _01657_ VGND VGND VPWR VPWR rf\[28\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_05848_ _02765_ VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__clkbuf_1
XTAP_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05779_ _02088_ rf\[22\]\[13\] _02711_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__mux2_1
XFILLER_23_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07518_ rf\[24\]\[20\] rf\[25\]\[20\] rf\[26\]\[20\] rf\[27\]\[20\] _03695_ _03696_
+ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__mux4_1
XFILLER_80_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07449_ rf\[8\]\[17\] rf\[9\]\[17\] rf\[10\]\[17\] rf\[11\]\[17\] _03691_ _03696_
+ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__mux4_2
XFILLER_22_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09119_ net217 _01091_ VGND VGND VPWR VPWR rf\[29\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08001__68 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__inv_2
XFILLER_73_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08622__654 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__inv_2
XFILLER_54_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08737__763 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04473_ clknet_0__04473_ VGND VGND VPWR VPWR clknet_1_1__leaf__04473_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_122_381 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06820_ _03261_ _03335_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__or2_1
XFILLER_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06751_ _03261_ _03269_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__or2_1
XFILLER_49_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09470_ net568 _01442_ VGND VGND VPWR VPWR rf\[21\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_05702_ _02690_ VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__clkbuf_1
X_06682_ _03202_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__buf_12
X_08482__522 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__inv_2
XFILLER_64_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05633_ _02654_ VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__clkbuf_1
X_05564_ _02618_ VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__clkbuf_1
X_05495_ _02582_ VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__clkbuf_1
X_08597__631 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__inv_2
X_04515_ _02057_ VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__clkbuf_1
X_07303_ _03578_ _03795_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__or2_1
X_07234_ _03716_ _03721_ _03730_ _03650_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__o211a_1
XFILLER_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07165_ rf\[24\]\[2\] rf\[25\]\[2\] rf\[26\]\[2\] rf\[27\]\[2\] _03604_ _03613_ VGND
+ VGND VPWR VPWR _03665_ sky130_fd_sc_hd__mux4_1
X_08105__166 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__inv_2
XFILLER_3_409 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06116_ rf\[17\]\[10\] _02094_ _02882_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__mux2_1
X_07096_ _03587_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__clkbuf_16
XFILLER_117_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06047_ _02868_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09806_ net904 _01778_ VGND VGND VPWR VPWR rf\[8\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09737_ net835 _01709_ VGND VGND VPWR VPWR rf\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06949_ _03205_ _03455_ _03457_ _03216_ VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__a31o_1
XFILLER_55_652 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_630 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09668_ net766 _01640_ VGND VGND VPWR VPWR rf\[27\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08645__676 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__inv_2
XTAP_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09599_ net697 _01571_ VGND VGND VPWR VPWR rf\[25\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_688 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04493_ clknet_0__04493_ VGND VGND VPWR VPWR clknet_1_0__leaf__04493_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_42_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05280_ rf\[2\]\[29\] _02056_ _02468_ VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__mux2_1
X_08128__188 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__inv_2
X_08932__948 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1060 sky130_fd_sc_hd__inv_2
XFILLER_115_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08553__589 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__inv_2
X_07921_ rf\[20\]\[9\] rf\[21\]\[9\] rf\[22\]\[9\] rf\[23\]\[9\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _04382_ sky130_fd_sc_hd__mux4_1
XFILLER_69_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f__04456_ clknet_0__04456_ VGND VGND VPWR VPWR clknet_1_1__leaf__04456_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07852_ rf\[0\]\[6\] rf\[1\]\[6\] rf\[2\]\[6\] rf\[3\]\[6\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04316_ sky130_fd_sc_hd__mux4_1
Xclkbuf_0__04487_ _04487_ VGND VGND VPWR VPWR clknet_0__04487_ sky130_fd_sc_hd__clkbuf_16
Xinput1 port1_reg_i[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XFILLER_84_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08668__698 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__inv_2
XFILLER_68_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06803_ _03196_ _03319_ _03203_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__o21a_1
X_09522_ net620 _01494_ VGND VGND VPWR VPWR rf\[23\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07783_ rf\[16\]\[2\] rf\[17\]\[2\] rf\[18\]\[2\] rf\[19\]\[2\] _03197_ _03192_ VGND
+ VGND VPWR VPWR _04251_ sky130_fd_sc_hd__mux4_2
X_04995_ rf\[10\]\[6\] _02102_ _02297_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__mux2_1
XFILLER_83_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06734_ _03197_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__buf_12
X_09453_ net551 _01425_ VGND VGND VPWR VPWR rf\[20\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_06665_ _03186_ VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05616_ rf\[24\]\[28\] _02058_ _02642_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__mux2_1
XFILLER_101_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09384_ net482 _01356_ VGND VGND VPWR VPWR rf\[18\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_51_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06596_ _02110_ rf\[29\]\[2\] _03121_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__mux2_1
XFILLER_52_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05547_ _02056_ rf\[25\]\[29\] _02607_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__mux2_1
XFILLER_20_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05478_ _02054_ rf\[26\]\[30\] _02572_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__mux2_1
X_07217_ rf\[4\]\[5\] rf\[5\]\[5\] rf\[6\]\[5\] rf\[7\]\[5\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03714_ sky130_fd_sc_hd__mux4_1
X_07148_ _03641_ _03643_ _03645_ _03648_ _03608_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__a221o_1
XFILLER_106_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07079_ net6 VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__buf_8
XFILLER_86_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10090_ net126 _01038_ VGND VGND VPWR VPWR rf\[31\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04476_ clknet_0__04476_ VGND VGND VPWR VPWR clknet_1_0__leaf__04476_
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08513__551 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__inv_2
XFILLER_25_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08628__660 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__inv_2
X_04780_ rf\[4\]\[12\] _02090_ _02190_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__mux2_1
XFILLER_18_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06450_ rf\[12\]\[9\] _02096_ _03054_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__mux2_1
X_05401_ _02110_ rf\[28\]\[2\] _02502_ VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__mux2_1
XFILLER_21_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06381_ _02094_ rf\[13\]\[10\] _03019_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__mux2_1
XFILLER_33_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05332_ rf\[2\]\[3\] _02108_ _02467_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__mux2_1
X_05263_ _02461_ VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__clkbuf_1
X_07002_ _03242_ _03507_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__or2_1
X_05194_ _02425_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__clkbuf_1
XFILLER_115_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08953_ clknet_1_1__leaf__04490_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__buf_1
X_07904_ _03261_ _04365_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__or2_1
XFILLER_111_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07835_ _03261_ _04299_ net4 VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__o21a_1
X_07766_ rf\[0\]\[1\] rf\[1\]\[1\] rf\[2\]\[1\] rf\[3\]\[1\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _04235_ sky130_fd_sc_hd__mux4_1
X_04978_ _02314_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09505_ net603 _01477_ VGND VGND VPWR VPWR rf\[22\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_06717_ rf\[12\]\[14\] rf\[13\]\[14\] rf\[14\]\[14\] rf\[15\]\[14\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__mux4_1
X_09436_ net534 _01408_ VGND VGND VPWR VPWR rf\[20\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_07697_ _04155_ _04160_ _04169_ _03612_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__o211a_2
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08800__823 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__inv_2
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06648_ rf\[0\]\[8\] VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__clkbuf_1
X_06579_ _03143_ VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__clkbuf_1
X_09367_ net465 _01339_ VGND VGND VPWR VPWR rf\[18\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_09298_ net396 _01270_ VGND VGND VPWR VPWR rf\[16\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_08421__464 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__inv_2
XFILLER_125_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_87 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08536__573 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__inv_2
XFILLER_106_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08028__93 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__inv_2
XFILLER_106_498 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10073_ net164 _02045_ VGND VGND VPWR VPWR rf\[31\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08281__332 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__inv_2
Xclkbuf_1_0__f__04459_ clknet_0__04459_ VGND VGND VPWR VPWR clknet_1_0__leaf__04459_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08396__441 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__inv_2
XFILLER_7_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05950_ rf\[1\]\[27\] _02060_ _02814_ VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__mux2_1
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05881_ _02783_ VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__clkbuf_1
XFILLER_93_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04901_ _02274_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__clkbuf_1
X_04832_ rf\[5\]\[20\] _02074_ _02226_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__mux2_1
X_07620_ rf\[12\]\[26\] rf\[13\]\[26\] rf\[14\]\[26\] rf\[15\]\[26\] _03589_ _03584_
+ VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__mux4_2
X_07551_ _03603_ _04030_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__or2_1
XFILLER_81_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06502_ rf\[11\]\[16\] net18 _03088_ VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__mux2_1
X_04763_ _02201_ VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__clkbuf_1
X_04694_ rf\[19\]\[21\] _02072_ _02154_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__mux2_1
X_07482_ rf\[28\]\[18\] rf\[29\]\[18\] rf\[30\]\[18\] rf\[31\]\[18\] _03646_ _03600_
+ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__mux4_2
XFILLER_34_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08444__486 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__inv_2
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09221_ net319 _01193_ VGND VGND VPWR VPWR rf\[13\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_06433_ _03068_ VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__clkbuf_1
X_09152_ net250 _01124_ VGND VGND VPWR VPWR rf\[11\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06364_ _03032_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__clkbuf_1
X_05315_ _02488_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08559__595 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__inv_2
X_09083_ net181 _01055_ VGND VGND VPWR VPWR rf\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_06295_ _02074_ rf\[14\]\[20\] _02985_ VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__mux2_1
X_05246_ _02088_ rf\[30\]\[13\] _02434_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__mux2_1
X_05177_ rf\[9\]\[14\] _02086_ _02399_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__mux2_1
XFILLER_107_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09985_ net1083 _01957_ VGND VGND VPWR VPWR rf\[4\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07818_ _03206_ _04283_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__or2_1
XFILLER_83_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07749_ rf\[24\]\[0\] rf\[25\]\[0\] rf\[26\]\[0\] rf\[27\]\[0\] _03251_ _03221_ VGND
+ VGND VPWR VPWR _04219_ sky130_fd_sc_hd__mux4_1
XFILLER_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09419_ net517 _01391_ VGND VGND VPWR VPWR rf\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_636 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08731__758 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__inv_2
XFILLER_4_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_116 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08352__399 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__inv_2
X_10056_ net147 _02028_ VGND VGND VPWR VPWR rf\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_544 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06080_ rf\[17\]\[28\] _02058_ _02882_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__mux2_1
X_05100_ _02377_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__clkbuf_1
X_05031_ rf\[7\]\[21\] _02072_ _02331_ VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__mux2_1
XFILLER_125_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_232 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08007__74 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__inv_2
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09770_ net868 _01742_ VGND VGND VPWR VPWR rf\[30\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06982_ _03247_ _03488_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__or2_1
X_05933_ _02809_ VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__clkbuf_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08652_ clknet_1_1__leaf__04479_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__buf_1
X_05864_ _02773_ VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__clkbuf_1
X_07603_ rf\[16\]\[25\] rf\[17\]\[25\] rf\[18\]\[25\] rf\[19\]\[25\] _03639_ _03631_
+ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__mux4_1
X_05795_ _02104_ rf\[22\]\[5\] _02710_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__mux2_1
X_04815_ _02229_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__clkbuf_1
X_07534_ rf\[16\]\[21\] rf\[17\]\[21\] rf\[18\]\[21\] rf\[19\]\[21\] _03639_ _03631_
+ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__mux4_1
XFILLER_81_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04746_ rf\[4\]\[29\] _02056_ _02190_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__mux2_1
XFILLER_53_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07465_ _03612_ _03940_ _03949_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__and3_4
X_04677_ _02156_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__clkbuf_1
X_09204_ net302 _01176_ VGND VGND VPWR VPWR rf\[13\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_06416_ rf\[12\]\[26\] _02062_ _03054_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__mux2_1
X_07396_ _03588_ _03883_ _03597_ VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__o21a_1
X_09135_ net233 _01107_ VGND VGND VPWR VPWR rf\[11\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_06347_ _02060_ rf\[13\]\[27\] _03019_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__mux2_1
X_06278_ _02988_ VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__clkbuf_1
X_05229_ _02444_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09968_ net1066 _01940_ VGND VGND VPWR VPWR rf\[4\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09899_ net997 _01871_ VGND VGND VPWR VPWR rf\[10\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_08312__361 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__inv_2
XFILLER_27_86 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08427__470 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__inv_2
XFILLER_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09060__8 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__inv_2
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_552 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10039_ net130 _02011_ VGND VGND VPWR VPWR rf\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05580_ _02626_ VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__clkbuf_1
XFILLER_91_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04600_ net11 VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__buf_12
X_04531_ net26 VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__buf_12
X_07250_ rf\[28\]\[6\] rf\[29\]\[6\] rf\[30\]\[6\] rf\[31\]\[6\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _03746_ sky130_fd_sc_hd__mux4_2
X_06201_ _02947_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__clkbuf_1
X_07181_ _03625_ _03679_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__or2_1
X_06132_ rf\[17\]\[2\] _02110_ _02881_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__mux2_1
X_06063_ _02876_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__clkbuf_1
X_08220__274 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__inv_2
XFILLER_125_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05014_ _02333_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09822_ net920 _01794_ VGND VGND VPWR VPWR rf\[8\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_09753_ net851 _01725_ VGND VGND VPWR VPWR rf\[30\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_08335__383 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__inv_2
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_650 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06965_ _03261_ _03472_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__or2_1
X_06896_ rf\[24\]\[22\] rf\[25\]\[22\] rf\[26\]\[22\] rf\[27\]\[22\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__mux4_1
X_05916_ rf\[20\]\[11\] _02092_ _02780_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__mux2_1
X_09684_ net782 _01656_ VGND VGND VPWR VPWR rf\[28\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_05847_ _02090_ rf\[21\]\[12\] _02745_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__mux2_1
XFILLER_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05778_ _02729_ VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__clkbuf_1
X_07517_ _03699_ _03998_ _03594_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__o21a_1
XFILLER_35_591 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04729_ _02182_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__clkbuf_1
X_07448_ _03587_ _03932_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__or2_1
XFILLER_50_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07379_ rf\[16\]\[13\] rf\[17\]\[13\] rf\[18\]\[13\] rf\[19\]\[13\] _03639_ _03631_
+ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__mux4_1
X_08875__893 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1005 sky130_fd_sc_hd__inv_2
XFILLER_108_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09118_ net216 _01090_ VGND VGND VPWR VPWR rf\[29\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08080__142 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__inv_2
XFILLER_2_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08195__251 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__inv_2
XFILLER_89_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_514 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08243__296 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__inv_2
XFILLER_62_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04472_ clknet_0__04472_ VGND VGND VPWR VPWR clknet_1_1__leaf__04472_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_122_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06750_ rf\[0\]\[15\] rf\[1\]\[15\] rf\[2\]\[15\] rf\[3\]\[15\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _03269_ sky130_fd_sc_hd__mux4_2
X_05701_ _02076_ rf\[23\]\[19\] _02677_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__mux2_1
X_06681_ net4 VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__inv_2
XFILLER_64_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05632_ rf\[24\]\[20\] _02074_ _02642_ VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__mux2_1
X_05563_ _02072_ rf\[25\]\[21\] _02607_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__mux2_1
X_05494_ _02070_ rf\[26\]\[22\] _02572_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__mux2_1
X_04514_ _02056_ rf\[31\]\[29\] _02052_ VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__mux2_1
X_07302_ rf\[16\]\[9\] rf\[17\]\[9\] rf\[18\]\[9\] rf\[19\]\[9\] _03589_ _03584_ VGND
+ VGND VPWR VPWR _03795_ sky130_fd_sc_hd__mux4_1
XFILLER_20_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07233_ _03723_ _03725_ _03727_ _03729_ _03623_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__a221o_2
X_07164_ _03598_ _03663_ _03595_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__o21a_1
XFILLER_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06115_ _02903_ VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__clkbuf_1
X_07095_ net9 VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__clkbuf_16
X_09023__27 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__inv_2
X_06046_ rf\[18\]\[12\] _02090_ _02848_ VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__mux2_1
XFILLER_87_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08530__568 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__inv_2
X_09805_ net903 _01777_ VGND VGND VPWR VPWR rf\[9\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09736_ net834 _01708_ VGND VGND VPWR VPWR rf\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_07990__57 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__inv_2
X_06948_ _03211_ _03456_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__or2_1
X_09667_ net765 _01639_ VGND VGND VPWR VPWR rf\[27\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06879_ rf\[8\]\[21\] rf\[9\]\[21\] rf\[10\]\[21\] rf\[11\]\[21\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__mux4_1
X_09598_ net696 _01570_ VGND VGND VPWR VPWR rf\[25\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04492_ clknet_0__04492_ VGND VGND VPWR VPWR clknet_1_0__leaf__04492_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_42_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08466__507 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__inv_2
XFILLER_77_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_90 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07920_ _03261_ _04380_ VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__or2_1
Xclkbuf_1_1__f__04455_ clknet_0__04455_ VGND VGND VPWR VPWR clknet_1_1__leaf__04455_
+ sky130_fd_sc_hd__clkbuf_16
X_07851_ _04315_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_1
XFILLER_110_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__04486_ _04486_ VGND VGND VPWR VPWR clknet_0__04486_ sky130_fd_sc_hd__clkbuf_16
Xinput2 port1_reg_i[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_4
XFILLER_84_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06802_ rf\[4\]\[17\] rf\[5\]\[17\] rf\[6\]\[17\] rf\[7\]\[17\] _03254_ _03199_ VGND
+ VGND VPWR VPWR _03319_ sky130_fd_sc_hd__mux4_2
X_07782_ _04243_ _04245_ _04247_ _04249_ _03216_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__a221o_1
X_09521_ net619 _01493_ VGND VGND VPWR VPWR rf\[23\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06733_ _03211_ _03252_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__or2_1
XFILLER_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04994_ _02322_ VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09452_ net550 _01424_ VGND VGND VPWR VPWR rf\[20\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06664_ rf\[0\]\[0\] VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_24_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05615_ _02645_ VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__clkbuf_1
XFILLER_91_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09383_ net481 _01355_ VGND VGND VPWR VPWR rf\[18\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_06595_ _03151_ VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__clkbuf_1
X_08111__171 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__inv_2
X_05546_ _02609_ VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__clkbuf_1
X_05477_ _02573_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__clkbuf_1
X_08226__280 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__inv_2
X_07216_ rf\[0\]\[5\] rf\[1\]\[5\] rf\[2\]\[5\] rf\[3\]\[5\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03713_ sky130_fd_sc_hd__mux4_1
XFILLER_106_614 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07147_ _03580_ _03647_ _03597_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__o21a_1
XFILLER_105_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07078_ _03579_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__buf_12
X_06029_ _02859_ VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__clkbuf_1
X_08489__529 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__inv_2
XFILLER_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09719_ net817 _01691_ VGND VGND VPWR VPWR rf\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04475_ clknet_0__04475_ VGND VGND VPWR VPWR clknet_1_0__leaf__04475_
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_166 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08134__193 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__inv_2
XFILLER_19_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05400_ _02532_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__clkbuf_1
XTAP_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06380_ _03040_ VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__clkbuf_1
X_05331_ _02496_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__clkbuf_1
X_05262_ _02104_ rf\[30\]\[5\] _02433_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__mux2_1
X_07001_ rf\[16\]\[28\] rf\[17\]\[28\] rf\[18\]\[28\] rf\[19\]\[28\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__mux4_1
X_05193_ rf\[9\]\[6\] _02102_ _02399_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__mux2_1
XFILLER_103_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07903_ rf\[24\]\[8\] rf\[25\]\[8\] rf\[26\]\[8\] rf\[27\]\[8\] _03197_ _03192_ VGND
+ VGND VPWR VPWR _04365_ sky130_fd_sc_hd__mux4_1
XFILLER_96_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07834_ rf\[8\]\[5\] rf\[9\]\[5\] rf\[10\]\[5\] rf\[11\]\[5\] _03262_ _03268_ VGND
+ VGND VPWR VPWR _04299_ sky130_fd_sc_hd__mux4_2
XFILLER_29_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0__04469_ _04469_ VGND VGND VPWR VPWR clknet_0__04469_ sky130_fd_sc_hd__clkbuf_16
XFILLER_84_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04977_ rf\[10\]\[15\] _02084_ _02297_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__mux2_1
XFILLER_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07765_ _03206_ _04233_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__or2_1
XFILLER_112_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09504_ net602 _01476_ VGND VGND VPWR VPWR rf\[22\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_07696_ _04162_ _04164_ _04166_ _04168_ _03623_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__a221o_1
X_06716_ _03188_ _03233_ _03235_ _03203_ VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__o211a_1
X_09435_ net533 _01407_ VGND VGND VPWR VPWR rf\[20\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06647_ _03177_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06578_ _02092_ rf\[29\]\[11\] _03122_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__mux2_1
X_09366_ net464 _01338_ VGND VGND VPWR VPWR rf\[18\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05529_ _02599_ VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__clkbuf_1
X_09297_ net395 _01269_ VGND VGND VPWR VPWR rf\[16\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10072_ net163 _02044_ VGND VGND VPWR VPWR rf\[31\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08961__975 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1087 sky130_fd_sc_hd__inv_2
XFILLER_28_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f__04458_ clknet_0__04458_ VGND VGND VPWR VPWR clknet_1_0__leaf__04458_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_30_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08357__404 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__inv_2
XFILLER_7_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_403 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04900_ rf\[6\]\[20\] _02074_ _02262_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__mux2_1
X_05880_ rf\[20\]\[29\] _02056_ _02780_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__mux2_1
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04831_ _02237_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__clkbuf_1
X_07550_ rf\[8\]\[22\] rf\[9\]\[22\] rf\[10\]\[22\] rf\[11\]\[22\] _03604_ _03613_
+ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__mux4_1
X_08897__914 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1026 sky130_fd_sc_hd__inv_2
X_04762_ rf\[4\]\[21\] _02072_ _02190_ VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__mux2_1
X_06501_ _03103_ VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__clkbuf_1
XFILLER_46_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07481_ _03629_ _03964_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__or2_1
X_04693_ _02164_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__clkbuf_1
X_09220_ net318 _01192_ VGND VGND VPWR VPWR rf\[13\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06432_ rf\[12\]\[18\] _02078_ _03054_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__mux2_1
X_09151_ net249 _01123_ VGND VGND VPWR VPWR rf\[11\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06363_ _02076_ rf\[13\]\[19\] _03019_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__mux2_1
X_09082_ net180 _01054_ VGND VGND VPWR VPWR rf\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_05314_ rf\[2\]\[12\] _02090_ _02468_ VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__mux2_1
X_06294_ _02996_ VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__clkbuf_1
X_05245_ _02452_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__clkbuf_1
XFILLER_89_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05176_ _02416_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__clkbuf_1
XFILLER_103_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09984_ net1082 _01956_ VGND VGND VPWR VPWR rf\[4\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08984__997 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1109 sky130_fd_sc_hd__inv_2
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08150__208 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__inv_2
XFILLER_123_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07817_ rf\[12\]\[4\] rf\[13\]\[4\] rf\[14\]\[4\] rf\[15\]\[4\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04283_ sky130_fd_sc_hd__mux4_1
X_07748_ _03247_ _04217_ _03273_ VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__o21a_1
XFILLER_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08265__317 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__inv_2
X_07679_ rf\[0\]\[29\] rf\[1\]\[29\] rf\[2\]\[29\] rf\[3\]\[29\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _04152_ sky130_fd_sc_hd__mux4_1
XFILLER_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09418_ net516 _01390_ VGND VGND VPWR VPWR rf\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_648 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09349_ net447 _01321_ VGND VGND VPWR VPWR rf\[17\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_574 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10055_ net146 _02027_ VGND VGND VPWR VPWR rf\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05030_ _02341_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06981_ rf\[4\]\[27\] rf\[5\]\[27\] rf\[6\]\[27\] rf\[7\]\[27\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03488_ sky130_fd_sc_hd__mux4_1
X_05932_ rf\[20\]\[3\] _02108_ _02779_ VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__mux2_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05863_ _02106_ rf\[21\]\[4\] _02744_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__mux2_1
XFILLER_39_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07602_ _03699_ _04078_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__or2_1
XFILLER_81_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08288__339 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__inv_2
X_04814_ rf\[5\]\[29\] _02056_ _02226_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__mux2_1
XFILLER_27_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05794_ _02737_ VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__clkbuf_1
X_04745_ _02192_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__clkbuf_1
X_07533_ _03597_ _04011_ _04013_ _03608_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__a31o_1
X_07464_ _03942_ _03944_ _03946_ _03948_ _03622_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__a221o_1
X_04676_ rf\[19\]\[30\] _02054_ _02154_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__mux2_1
XFILLER_34_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09203_ net301 _01175_ VGND VGND VPWR VPWR rf\[13\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06415_ _03059_ VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__clkbuf_1
X_07395_ rf\[28\]\[14\] rf\[29\]\[14\] rf\[30\]\[14\] rf\[31\]\[14\] _03583_ _03585_
+ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__mux4_1
X_09134_ net232 _01106_ VGND VGND VPWR VPWR rf\[11\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06346_ _03023_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__clkbuf_1
X_06277_ _02056_ rf\[14\]\[29\] _02985_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__mux2_1
X_05228_ _02070_ rf\[30\]\[22\] _02434_ VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__mux2_1
XFILLER_118_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05159_ rf\[9\]\[23\] _02068_ _02399_ VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__mux2_1
X_09967_ net1065 _01939_ VGND VGND VPWR VPWR rf\[4\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08013__78 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__inv_2
XFILLER_94_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09898_ net996 _01870_ VGND VGND VPWR VPWR rf\[10\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09029__33 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__inv_2
X_09044__47 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__inv_2
X_08852__872 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__inv_2
XFILLER_107_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07996__63 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__inv_2
XFILLER_4_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_564 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08967__981 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1093 sky130_fd_sc_hd__inv_2
XFILLER_110_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_662 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10038_ net1136 _02010_ VGND VGND VPWR VPWR rf\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_386 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08248__301 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__inv_2
XFILLER_84_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04530_ _02067_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06200_ rf\[16\]\[1\] _02112_ _02915_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__mux2_1
X_08673__702 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__inv_2
X_07180_ rf\[4\]\[3\] rf\[5\]\[3\] rf\[6\]\[3\] rf\[7\]\[3\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03679_ sky130_fd_sc_hd__mux4_1
XFILLER_117_314 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06131_ _02911_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__clkbuf_1
X_06062_ rf\[18\]\[4\] _02106_ _02847_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__mux2_1
XFILLER_99_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05013_ rf\[7\]\[30\] _02054_ _02331_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__mux2_1
XFILLER_98_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09821_ net919 _01793_ VGND VGND VPWR VPWR rf\[8\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09752_ net850 _01724_ VGND VGND VPWR VPWR rf\[30\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06964_ rf\[0\]\[26\] rf\[1\]\[26\] rf\[2\]\[26\] rf\[3\]\[26\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _03472_ sky130_fd_sc_hd__mux4_1
X_05915_ _02800_ VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__clkbuf_1
X_06895_ _03247_ _03406_ _03273_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__o21a_1
XFILLER_82_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09683_ net781 _01655_ VGND VGND VPWR VPWR rf\[28\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05846_ _02764_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__clkbuf_1
XFILLER_27_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05777_ _02086_ rf\[22\]\[14\] _02711_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__mux2_1
XTAP_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07516_ rf\[20\]\[20\] rf\[21\]\[20\] rf\[22\]\[20\] rf\[23\]\[20\] _03695_ _03696_
+ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__mux4_2
XFILLER_81_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04728_ rf\[19\]\[4\] _02106_ _02153_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__mux2_1
X_08760__785 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__inv_2
X_04659_ rf\[3\]\[5\] _02104_ _02118_ VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__mux2_1
XFILLER_22_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07447_ rf\[12\]\[17\] rf\[13\]\[17\] rf\[14\]\[17\] rf\[15\]\[17\] _03589_ _03584_
+ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__mux4_2
X_07378_ _03597_ _03864_ _03866_ _03608_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__a31o_1
X_08836__856 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__inv_2
X_08041__105 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__inv_2
X_09117_ net215 _01089_ VGND VGND VPWR VPWR rf\[29\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_06329_ _02108_ rf\[14\]\[3\] _02984_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__mux2_1
XFILLER_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08156__214 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__inv_2
XFILLER_89_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08696__724 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__inv_2
XFILLER_9_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_595 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04471_ clknet_0__04471_ VGND VGND VPWR VPWR clknet_1_1__leaf__04471_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08319__368 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__inv_2
XFILLER_95_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05700_ _02689_ VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06680_ _03196_ _03200_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__or2_1
XFILLER_36_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05631_ _02653_ VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__clkbuf_1
XFILLER_91_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08350_ clknet_1_1__leaf__04457_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__buf_1
XFILLER_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05562_ _02617_ VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__clkbuf_1
X_07301_ _03787_ _03789_ _03791_ _03793_ _03608_ VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__a221o_1
X_05493_ _02581_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__clkbuf_1
X_04513_ net32 VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__buf_12
X_08859__878 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__inv_2
XFILLER_20_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07232_ _03588_ _03728_ _03597_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__o21a_1
X_08064__127 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__inv_2
XFILLER_118_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07163_ rf\[20\]\[2\] rf\[21\]\[2\] rf\[22\]\[2\] rf\[23\]\[2\] _03662_ _03600_ VGND
+ VGND VPWR VPWR _03663_ sky130_fd_sc_hd__mux4_2
XFILLER_118_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06114_ rf\[17\]\[11\] _02092_ _02882_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__mux2_1
X_07094_ _03580_ _03586_ _03593_ _03595_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__o211a_1
X_08179__236 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__inv_2
X_06045_ _02867_ VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__clkbuf_1
XFILLER_87_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_595 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09804_ net902 _01776_ VGND VGND VPWR VPWR rf\[9\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_09735_ net833 _01707_ VGND VGND VPWR VPWR rf\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_06947_ rf\[8\]\[25\] rf\[9\]\[25\] rf\[10\]\[25\] rf\[11\]\[25\] _03212_ _03221_
+ VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__mux4_1
X_09666_ net764 _01638_ VGND VGND VPWR VPWR rf\[27\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06878_ _03206_ _03390_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__or2_1
X_09597_ net695 _01569_ VGND VGND VPWR VPWR rf\[25\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_05829_ _02072_ rf\[21\]\[21\] _02745_ VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__mux2_1
XTAP_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f__04491_ clknet_0__04491_ VGND VGND VPWR VPWR clknet_1_0__leaf__04491_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_42_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_604 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08087__149 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__inv_2
XFILLER_33_359 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08891__909 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1021 sky130_fd_sc_hd__inv_2
XFILLER_14_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08819__840 clknet_1_1__leaf__04491_ VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__inv_2
XFILLER_114_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f__04454_ clknet_0__04454_ VGND VGND VPWR VPWR clknet_1_1__leaf__04454_
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0__04485_ _04485_ VGND VGND VPWR VPWR clknet_0__04485_ sky130_fd_sc_hd__clkbuf_16
X_07850_ _03220_ _04305_ _04314_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__and3_4
XFILLER_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04993_ rf\[10\]\[7\] _02100_ _02297_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__mux2_1
X_07781_ _03271_ _04248_ _03273_ VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__o21a_1
X_06801_ _03211_ _03317_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__or2_1
Xinput3 port1_reg_i[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
X_06732_ rf\[24\]\[14\] rf\[25\]\[14\] rf\[26\]\[14\] rf\[27\]\[14\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__mux4_2
X_09520_ net618 _01492_ VGND VGND VPWR VPWR rf\[23\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09451_ net549 _01423_ VGND VGND VPWR VPWR rf\[20\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06663_ _03185_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05614_ rf\[24\]\[29\] _02056_ _02642_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__mux2_1
X_09382_ net480 _01354_ VGND VGND VPWR VPWR rf\[18\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06594_ _02108_ rf\[29\]\[3\] _03121_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__mux2_1
X_05545_ _02054_ rf\[25\]\[30\] _02607_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__mux2_1
XFILLER_20_510 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_381 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05476_ _02048_ rf\[26\]\[31\] _02572_ VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__mux2_1
XFILLER_20_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07215_ _03712_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_1
XFILLER_106_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07146_ rf\[8\]\[1\] rf\[9\]\[1\] rf\[10\]\[1\] rf\[11\]\[1\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _03647_ sky130_fd_sc_hd__mux4_1
XFILLER_106_626 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07077_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__buf_8
X_06028_ rf\[18\]\[21\] _02072_ _02848_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__mux2_1
XFILLER_121_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08651__682 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__inv_2
XFILLER_59_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07979_ _03211_ _04436_ _03273_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__o21a_1
XFILLER_19_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08766__791 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__inv_2
X_09718_ net816 _01690_ VGND VGND VPWR VPWR rf\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_28_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09649_ net747 _01621_ VGND VGND VPWR VPWR rf\[27\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f__04474_ clknet_0__04474_ VGND VGND VPWR VPWR clknet_1_0__leaf__04474_
+ sky130_fd_sc_hd__clkbuf_16
X_08047__111 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__inv_2
XTAP_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08472__512 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__inv_2
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_218 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05330_ rf\[2\]\[4\] _02106_ _02467_ VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__mux2_1
X_05261_ _02460_ VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__clkbuf_1
X_07000_ _03271_ _03505_ VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__or2_1
X_05192_ _02424_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__clkbuf_1
X_08635__666 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__inv_2
XFILLER_103_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07902_ _03271_ _04363_ _03202_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__o21a_1
XFILLER_111_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04468_ _04468_ VGND VGND VPWR VPWR clknet_0__04468_ sky130_fd_sc_hd__clkbuf_16
X_07833_ _03195_ _04297_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__or2_1
XFILLER_84_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04976_ _02313_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__clkbuf_1
X_07764_ rf\[4\]\[1\] rf\[5\]\[1\] rf\[6\]\[1\] rf\[7\]\[1\] _03190_ _03244_ VGND
+ VGND VPWR VPWR _04233_ sky130_fd_sc_hd__mux4_1
XFILLER_112_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09503_ net601 _01475_ VGND VGND VPWR VPWR rf\[22\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_07695_ _03588_ _04167_ _03693_ VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__o21a_1
X_06715_ _03196_ _03234_ VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__or2_1
XFILLER_25_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09434_ net532 _01406_ VGND VGND VPWR VPWR rf\[20\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06646_ rf\[0\]\[9\] VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__clkbuf_1
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06577_ _03142_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__clkbuf_1
X_09365_ net463 _01337_ VGND VGND VPWR VPWR rf\[18\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05528_ _02104_ rf\[26\]\[5\] _02571_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__mux2_1
X_09296_ net394 _01268_ VGND VGND VPWR VPWR rf\[16\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_08495__534 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__inv_2
X_05459_ _02563_ VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__clkbuf_1
X_07129_ _03581_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__buf_12
XFILLER_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10071_ net162 _02043_ VGND VGND VPWR VPWR rf\[31\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08118__178 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__inv_2
X_08922__938 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1050 sky130_fd_sc_hd__inv_2
XFILLER_71_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f__04457_ clknet_0__04457_ VGND VGND VPWR VPWR clknet_1_0__leaf__04457_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_62_63 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08658__688 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__inv_2
XFILLER_125_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08019__84 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__inv_2
XFILLER_112_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08034__98 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__inv_2
XFILLER_66_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08782__806 clknet_1_1__leaf__04488_ VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__inv_2
XFILLER_78_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04830_ rf\[5\]\[21\] _02072_ _02226_ VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__mux2_1
XFILLER_81_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04761_ _02200_ VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__clkbuf_1
X_07480_ rf\[24\]\[18\] rf\[25\]\[18\] rf\[26\]\[18\] rf\[27\]\[18\] _03630_ _03613_
+ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__mux4_1
X_06500_ rf\[11\]\[17\] net19 _03088_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__mux2_1
X_04692_ rf\[19\]\[22\] _02070_ _02154_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__mux2_1
XFILLER_34_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06431_ _03067_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__clkbuf_1
X_09150_ net248 _01122_ VGND VGND VPWR VPWR rf\[11\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_06362_ _03031_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__clkbuf_1
X_05313_ _02487_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__clkbuf_1
X_06293_ _02072_ rf\[14\]\[21\] _02985_ VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__mux2_1
X_09081_ net179 _01053_ VGND VGND VPWR VPWR rf\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_05244_ _02086_ rf\[30\]\[14\] _02434_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__mux2_1
X_05175_ rf\[9\]\[15\] _02084_ _02399_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__mux2_1
XFILLER_107_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09983_ net1081 _01955_ VGND VGND VPWR VPWR rf\[4\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_332 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07816_ _03188_ _04279_ _04281_ _03203_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__o211a_1
XFILLER_57_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_708 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07747_ rf\[20\]\[0\] rf\[21\]\[0\] rf\[22\]\[0\] rf\[23\]\[0\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _04217_ sky130_fd_sc_hd__mux4_1
XFILLER_84_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04959_ rf\[10\]\[24\] _02066_ _02297_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__mux2_1
X_07678_ _04151_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
X_06629_ _03168_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__clkbuf_1
X_09417_ net515 _01389_ VGND VGND VPWR VPWR rf\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_09348_ net446 _01320_ VGND VGND VPWR VPWR rf\[17\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_108 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09279_ net377 _01251_ VGND VGND VPWR VPWR rf\[15\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_08690__719 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__inv_2
X_08618__650 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__inv_2
XFILLER_113_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10054_ net145 _02026_ VGND VGND VPWR VPWR rf\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06980_ rf\[0\]\[27\] rf\[1\]\[27\] rf\[2\]\[27\] rf\[3\]\[27\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03487_ sky130_fd_sc_hd__mux4_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05931_ _02808_ VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__clkbuf_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08450__492 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__inv_2
X_05862_ _02772_ VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__clkbuf_1
X_08905__922 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1034 sky130_fd_sc_hd__inv_2
XFILLER_39_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07601_ rf\[20\]\[25\] rf\[21\]\[25\] rf\[22\]\[25\] rf\[23\]\[25\] _03582_ _03626_
+ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__mux4_2
XFILLER_66_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04813_ _02228_ VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__clkbuf_1
XFILLER_26_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05793_ _02102_ rf\[22\]\[6\] _02711_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__mux2_1
XFILLER_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04744_ rf\[4\]\[30\] _02054_ _02190_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__mux2_1
X_07532_ _03603_ _04012_ VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__or2_1
X_07463_ _03699_ _03947_ _03693_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__o21a_1
X_04675_ _02155_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_22_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09202_ net300 _01174_ VGND VGND VPWR VPWR rf\[13\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_06414_ rf\[12\]\[27\] _02060_ _03054_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__mux2_1
X_07394_ _03580_ _03881_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__or2_1
X_09133_ net231 _01105_ VGND VGND VPWR VPWR rf\[29\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_06345_ _02058_ rf\[13\]\[28\] _03019_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__mux2_1
X_06276_ _02987_ VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__clkbuf_1
X_05227_ _02443_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__clkbuf_1
XFILLER_118_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05158_ _02407_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__clkbuf_1
X_08271__322 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__inv_2
X_09966_ net1064 _01938_ VGND VGND VPWR VPWR rf\[4\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_05089_ rf\[8\]\[25\] _02064_ _02365_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__mux2_1
XTAP_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09897_ net995 _01869_ VGND VGND VPWR VPWR rf\[10\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_287 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_576 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08434__476 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__inv_2
XFILLER_68_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08928__944 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1056 sky130_fd_sc_hd__inv_2
XFILLER_95_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10037_ net1135 _02009_ VGND VGND VPWR VPWR rf\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_84_50 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06130_ rf\[17\]\[3\] _02108_ _02881_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__mux2_1
XFILLER_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06061_ _02875_ VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__clkbuf_1
X_08294__344 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__inv_2
X_08788__812 clknet_1_1__leaf__04488_ VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__inv_2
X_05012_ _02332_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__clkbuf_1
XFILLER_98_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09820_ net918 _01792_ VGND VGND VPWR VPWR rf\[8\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09751_ net849 _01723_ VGND VGND VPWR VPWR rf\[30\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06963_ _03261_ _03470_ _03265_ VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__o21a_1
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05914_ rf\[20\]\[12\] _02090_ _02780_ VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__mux2_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06894_ rf\[20\]\[22\] rf\[21\]\[22\] rf\[22\]\[22\] rf\[23\]\[22\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__mux4_1
XFILLER_104_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09682_ net780 _01654_ VGND VGND VPWR VPWR rf\[28\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_05845_ _02088_ rf\[21\]\[13\] _02745_ VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__mux2_1
X_05776_ _02728_ VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__clkbuf_1
XTAP_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08721__748 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__inv_2
X_07515_ _03578_ _03996_ VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__or2_1
XFILLER_82_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04727_ _02181_ VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__clkbuf_1
X_08989__1002 clknet_1_1__leaf__04499_ VGND VGND VPWR VPWR net1114 sky130_fd_sc_hd__inv_2
X_07446_ _03917_ _03922_ _03931_ _03650_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__o211a_1
X_04658_ _02145_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__clkbuf_1
X_04589_ _02106_ rf\[31\]\[4\] _02051_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__mux2_1
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07377_ _03603_ _03865_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__or2_1
X_09116_ net214 _01088_ VGND VGND VPWR VPWR rf\[29\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_06328_ _03013_ VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__clkbuf_1
X_06259_ _02104_ rf\[15\]\[5\] _02950_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__mux2_1
X_08457__498 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__inv_2
XFILLER_123_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_576 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09949_ net1047 _01921_ VGND VGND VPWR VPWR rf\[5\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08581__616 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__inv_2
XFILLER_57_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04470_ clknet_0__04470_ VGND VGND VPWR VPWR clknet_1_1__leaf__04470_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05630_ rf\[24\]\[21\] _02072_ _02642_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__mux2_1
XFILLER_63_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05561_ _02070_ rf\[25\]\[22\] _02607_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__mux2_1
XFILLER_32_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07300_ _03699_ _03792_ _03682_ VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__o21a_1
X_05492_ _02068_ rf\[26\]\[23\] _02572_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__mux2_1
X_04512_ _02055_ VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07231_ rf\[28\]\[5\] rf\[29\]\[5\] rf\[30\]\[5\] rf\[31\]\[5\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _03728_ sky130_fd_sc_hd__mux4_1
X_07162_ _03581_ VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__buf_12
XFILLER_118_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06113_ _02902_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__clkbuf_1
X_09012__1024 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1136 sky130_fd_sc_hd__inv_2
X_07093_ _03594_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__buf_12
X_06044_ rf\[18\]\[13\] _02088_ _02848_ VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__mux2_1
X_08417__460 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__inv_2
XFILLER_115_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09803_ net901 _01775_ VGND VGND VPWR VPWR rf\[9\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09734_ net832 _01706_ VGND VGND VPWR VPWR rf\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_06946_ _03206_ _03454_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__or2_1
X_09665_ net763 _01637_ VGND VGND VPWR VPWR rf\[27\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_06877_ rf\[12\]\[21\] rf\[13\]\[21\] rf\[14\]\[21\] rf\[15\]\[21\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__mux4_1
X_05828_ _02755_ VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09596_ net694 _01568_ VGND VGND VPWR VPWR rf\[25\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_0__f__04490_ clknet_0__04490_ VGND VGND VPWR VPWR clknet_1_0__leaf__04490_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_42_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05759_ _02068_ rf\[22\]\[23\] _02711_ VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__mux2_1
XFILLER_35_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07429_ rf\[4\]\[16\] rf\[5\]\[16\] rf\[6\]\[16\] rf\[7\]\[16\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03915_ sky130_fd_sc_hd__mux4_1
XFILLER_50_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09014__18 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__inv_2
XFILLER_6_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08704__732 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__inv_2
XFILLER_45_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04453_ clknet_0__04453_ VGND VGND VPWR VPWR clknet_1_1__leaf__04453_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08988__1001 clknet_1_1__leaf__04499_ VGND VGND VPWR VPWR net1113 sky130_fd_sc_hd__inv_2
Xclkbuf_0__04484_ _04484_ VGND VGND VPWR VPWR clknet_0__04484_ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04992_ _02321_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__clkbuf_1
X_07780_ rf\[4\]\[2\] rf\[5\]\[2\] rf\[6\]\[2\] rf\[7\]\[2\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _04248_ sky130_fd_sc_hd__mux4_2
X_06800_ rf\[0\]\[17\] rf\[1\]\[17\] rf\[2\]\[17\] rf\[3\]\[17\] _03251_ _03221_ VGND
+ VGND VPWR VPWR _03317_ sky130_fd_sc_hd__mux4_1
Xinput4 port1_reg_i[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_6
X_08564__600 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__inv_2
X_06731_ _03189_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__buf_12
X_08070__132 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__inv_2
XFILLER_37_633 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09450_ net548 _01422_ VGND VGND VPWR VPWR rf\[20\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06662_ rf\[0\]\[1\] VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05613_ _02644_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__clkbuf_1
X_09381_ net479 _01353_ VGND VGND VPWR VPWR rf\[18\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_06593_ _03150_ VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05544_ _02608_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05475_ _02571_ VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__buf_12
X_07214_ _03612_ _03702_ _03711_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__and3_4
X_07145_ _03589_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__buf_12
XFILLER_106_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07076_ net8 VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__buf_8
X_06027_ _02858_ VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__clkbuf_1
XFILLER_87_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07978_ rf\[16\]\[12\] rf\[17\]\[12\] rf\[18\]\[12\] rf\[19\]\[12\] _03212_ _03213_
+ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__mux4_1
XFILLER_28_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08727__754 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__inv_2
XFILLER_74_216 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06929_ _03432_ _03434_ _03436_ _03438_ _03216_ VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__a221o_1
X_09717_ net815 _01689_ VGND VGND VPWR VPWR rf\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_08233__286 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__inv_2
X_09648_ net746 _01620_ VGND VGND VPWR VPWR rf\[27\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09579_ net677 _01551_ VGND VGND VPWR VPWR rf\[24\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04473_ clknet_0__04473_ VGND VGND VPWR VPWR clknet_1_0__leaf__04473_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_77 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_500 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08587__622 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__inv_2
XFILLER_78_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08093__154 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__inv_2
XFILLER_66_717 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09011__1023 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1135 sky130_fd_sc_hd__inv_2
XFILLER_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08520__558 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__inv_2
X_05260_ _02102_ rf\[30\]\[6\] _02434_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__mux2_1
X_05191_ rf\[9\]\[7\] _02100_ _02399_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__mux2_1
XFILLER_69_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07901_ rf\[20\]\[8\] rf\[21\]\[8\] rf\[22\]\[8\] rf\[23\]\[8\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04363_ sky130_fd_sc_hd__mux4_1
XFILLER_96_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04467_ _04467_ VGND VGND VPWR VPWR clknet_0__04467_ sky130_fd_sc_hd__clkbuf_16
X_07832_ rf\[12\]\[5\] rf\[13\]\[5\] rf\[14\]\[5\] rf\[15\]\[5\] _03197_ _03192_ VGND
+ VGND VPWR VPWR _04297_ sky130_fd_sc_hd__mux4_2
XFILLER_111_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09502_ net600 _01474_ VGND VGND VPWR VPWR rf\[22\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_07763_ _03203_ _04225_ _04227_ _04229_ _04231_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__a32o_1
X_04975_ rf\[10\]\[16\] _02082_ _02297_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__mux2_1
XFILLER_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07694_ rf\[28\]\[29\] rf\[29\]\[29\] rf\[30\]\[29\] rf\[31\]\[29\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__mux4_1
X_06714_ rf\[4\]\[14\] rf\[5\]\[14\] rf\[6\]\[14\] rf\[7\]\[14\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03234_ sky130_fd_sc_hd__mux4_2
X_09433_ net531 _01405_ VGND VGND VPWR VPWR rf\[20\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06645_ _03176_ VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__clkbuf_1
X_08380__426 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__inv_2
X_09364_ net462 _01336_ VGND VGND VPWR VPWR rf\[18\]\[6\] sky130_fd_sc_hd__dfxtp_1
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06576_ _02090_ rf\[29\]\[12\] _03122_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__mux2_1
X_05527_ _02598_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__clkbuf_1
X_09295_ net393 _01267_ VGND VGND VPWR VPWR rf\[16\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05458_ _02100_ rf\[27\]\[7\] _02538_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__mux2_1
XFILLER_20_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_424 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07128_ _03578_ VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__buf_6
X_05389_ _02098_ rf\[28\]\[8\] _02503_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__mux2_1
XFILLER_118_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07059_ _03247_ _03561_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__or2_1
XFILLER_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10070_ net161 _02042_ VGND VGND VPWR VPWR rf\[31\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_717 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_0__f__04456_ clknet_0__04456_ VGND VGND VPWR VPWR clknet_1_0__leaf__04456_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_62_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08987__1000 clknet_1_1__leaf__04499_ VGND VGND VPWR VPWR net1112 sky130_fd_sc_hd__inv_2
XFILLER_125_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_540 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08216__270 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__inv_2
XFILLER_120_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04760_ rf\[4\]\[22\] _02070_ _02190_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__mux2_1
XFILLER_93_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04691_ _02163_ VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__clkbuf_1
X_06430_ rf\[12\]\[19\] _02076_ _03054_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__mux2_1
X_08479__519 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__inv_2
XFILLER_21_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06361_ _02074_ rf\[13\]\[20\] _03019_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__mux2_1
X_09065__13 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__inv_2
X_05312_ rf\[2\]\[13\] _02088_ _02468_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__mux2_1
X_09080_ net178 _01052_ VGND VGND VPWR VPWR rf\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_06292_ _02995_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__clkbuf_1
X_05243_ _02451_ VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__clkbuf_1
Xinput40 wr_data_i[7] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
X_05174_ _02415_ VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__clkbuf_1
XFILLER_103_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09982_ net1080 _01954_ VGND VGND VPWR VPWR rf\[4\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08933_ clknet_1_1__leaf__04490_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__buf_1
XFILLER_97_650 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07815_ _03247_ _04280_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__or2_1
XFILLER_84_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07746_ _03261_ _04215_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__or2_1
X_04958_ _02304_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__clkbuf_1
XFILLER_44_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07677_ _03612_ _04141_ _04150_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__and3_4
X_09416_ net514 _01388_ VGND VGND VPWR VPWR rf\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04889_ _02268_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__clkbuf_1
X_06628_ rf\[0\]\[18\] VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08503__542 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__inv_2
X_09347_ net445 _01319_ VGND VGND VPWR VPWR rf\[17\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_06559_ _03133_ VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__clkbuf_1
X_09278_ net376 _01250_ VGND VGND VPWR VPWR rf\[15\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09010__1022 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1134 sky130_fd_sc_hd__inv_2
XFILLER_122_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08239__292 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__inv_2
XFILLER_0_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10053_ net144 _02025_ VGND VGND VPWR VPWR rf\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08363__410 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__inv_2
XFILLER_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_661 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_131 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08099__160 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__inv_2
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05930_ rf\[20\]\[4\] _02106_ _02779_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__mux2_1
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05861_ _02104_ rf\[21\]\[5\] _02744_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__mux2_1
XFILLER_78_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04812_ rf\[5\]\[30\] _02054_ _02226_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__mux2_1
X_07600_ _04063_ _04068_ _04077_ _03650_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__o211a_4
X_05792_ _02736_ VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__clkbuf_1
X_07531_ rf\[8\]\[21\] rf\[9\]\[21\] rf\[10\]\[21\] rf\[11\]\[21\] _03604_ _03613_
+ VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__mux4_1
XFILLER_81_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04743_ _02191_ VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__clkbuf_1
X_08526__564 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__inv_2
X_07462_ rf\[28\]\[17\] rf\[29\]\[17\] rf\[30\]\[17\] rf\[31\]\[17\] _03691_ _03626_
+ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__mux4_2
X_04674_ rf\[19\]\[31\] _02048_ _02154_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__mux2_1
XFILLER_34_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07393_ rf\[24\]\[14\] rf\[25\]\[14\] rf\[26\]\[14\] rf\[27\]\[14\] _03590_ _03591_
+ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__mux4_2
X_09201_ net299 _01173_ VGND VGND VPWR VPWR rf\[13\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06413_ _03058_ VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__clkbuf_1
X_09132_ net230 _01104_ VGND VGND VPWR VPWR rf\[29\]\[30\] sky130_fd_sc_hd__dfxtp_2
X_06344_ _03022_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_118_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06275_ _02054_ rf\[14\]\[30\] _02985_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__mux2_1
XFILLER_116_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05226_ _02068_ rf\[30\]\[23\] _02434_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__mux2_1
X_05157_ rf\[9\]\[24\] _02066_ _02399_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__mux2_1
XFILLER_104_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09965_ net1063 _01937_ VGND VGND VPWR VPWR rf\[5\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_05088_ _02371_ VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__clkbuf_1
XFILLER_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09896_ net994 _01868_ VGND VGND VPWR VPWR rf\[10\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_686 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08386__432 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__inv_2
XFILLER_38_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07729_ _03603_ _04199_ _03682_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__o21a_1
XFILLER_60_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10036_ net1134 _02008_ VGND VGND VPWR VPWR rf\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08549__586 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__inv_2
XFILLER_84_62 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08974__987 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1099 sky130_fd_sc_hd__inv_2
XFILLER_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06060_ rf\[18\]\[5\] _02104_ _02847_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__mux2_1
X_09035__38 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__inv_2
X_05011_ rf\[7\]\[31\] _02048_ _02331_ VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__mux2_1
X_08255__307 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__inv_2
XFILLER_125_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09750_ net848 _01722_ VGND VGND VPWR VPWR rf\[30\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06962_ rf\[8\]\[26\] rf\[9\]\[26\] rf\[10\]\[26\] rf\[11\]\[26\] _03262_ _03268_
+ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__mux4_1
X_05913_ _02799_ VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__clkbuf_1
XFILLER_100_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_491 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09681_ net779 _01653_ VGND VGND VPWR VPWR rf\[28\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08632_ clknet_1_1__leaf__04479_ VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__buf_1
X_06893_ _03242_ _03404_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__or2_1
XFILLER_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05844_ _02763_ VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__clkbuf_1
X_05775_ _02084_ rf\[22\]\[15\] _02711_ VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__mux2_1
XFILLER_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07514_ rf\[16\]\[20\] rf\[17\]\[20\] rf\[18\]\[20\] rf\[19\]\[20\] _03589_ _03584_
+ VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__mux4_1
X_04726_ rf\[19\]\[5\] _02104_ _02153_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__mux2_1
XFILLER_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07445_ _03924_ _03926_ _03928_ _03930_ _03623_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__a221o_1
XFILLER_81_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04657_ rf\[3\]\[6\] _02102_ _02119_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__mux2_1
X_07376_ rf\[8\]\[13\] rf\[9\]\[13\] rf\[10\]\[13\] rf\[11\]\[13\] _03604_ _03605_
+ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__mux4_1
X_04588_ net37 VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__buf_12
XFILLER_108_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09115_ net213 _01087_ VGND VGND VPWR VPWR rf\[29\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06327_ _02106_ rf\[14\]\[4\] _02984_ VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__mux2_1
X_06258_ _02977_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__clkbuf_1
X_05209_ _02433_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__buf_12
X_06189_ _02941_ VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09948_ net1046 _01920_ VGND VGND VPWR VPWR rf\[5\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09879_ net977 _01851_ VGND VGND VPWR VPWR rf\[10\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_18_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08278__329 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__inv_2
XFILLER_96_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10019_ net1117 _01991_ VGND VGND VPWR VPWR rf\[19\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05560_ _02616_ VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__clkbuf_1
XFILLER_91_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04511_ _02054_ rf\[31\]\[30\] _02052_ VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__mux2_1
XFILLER_63_199 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05491_ _02580_ VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_553 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07230_ _03603_ _03726_ VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__or2_1
XFILLER_20_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07161_ _03629_ _03660_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__or2_1
XFILLER_117_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06112_ rf\[17\]\[12\] _02090_ _02882_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__mux2_1
X_08302__352 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__inv_2
XFILLER_118_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07092_ net9 VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__clkinv_4
X_06043_ _02866_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__clkbuf_1
XFILLER_115_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09802_ net900 _01774_ VGND VGND VPWR VPWR rf\[9\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09733_ net831 _01705_ VGND VGND VPWR VPWR rf\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_06945_ rf\[12\]\[25\] rf\[13\]\[25\] rf\[14\]\[25\] rf\[15\]\[25\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__mux4_1
X_09664_ net762 _01636_ VGND VGND VPWR VPWR rf\[27\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06876_ _03188_ _03388_ _03273_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__o21a_1
X_05827_ _02070_ rf\[21\]\[22\] _02745_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__mux2_1
X_09595_ net693 _01567_ VGND VGND VPWR VPWR rf\[25\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08842__862 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__inv_2
XFILLER_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05758_ _02719_ VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__clkbuf_1
X_05689_ _02064_ rf\[23\]\[25\] _02677_ VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__mux2_1
X_04709_ _02172_ VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__clkbuf_1
X_08957__971 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1083 sky130_fd_sc_hd__inv_2
X_07428_ rf\[0\]\[16\] rf\[1\]\[16\] rf\[2\]\[16\] rf\[3\]\[16\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03914_ sky130_fd_sc_hd__mux4_1
X_08162__220 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__inv_2
XFILLER_50_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07359_ _03595_ _03842_ _03844_ _03846_ _03848_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__a32o_1
XFILLER_108_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_628 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08325__374 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__inv_2
XFILLER_115_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_1_1__f__04452_ clknet_0__04452_ VGND VGND VPWR VPWR clknet_1_1__leaf__04452_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_122_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0__04483_ _04483_ VGND VGND VPWR VPWR clknet_0__04483_ sky130_fd_sc_hd__clkbuf_16
X_08865__884 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__inv_2
X_04991_ rf\[10\]\[8\] _02098_ _02297_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__mux2_1
Xinput5 port1_reg_i[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_4
X_06730_ _03247_ _03249_ _03203_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__o21a_1
X_06661_ _03184_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05612_ rf\[24\]\[30\] _02054_ _02642_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__mux2_1
X_09380_ net478 _01352_ VGND VGND VPWR VPWR rf\[18\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06592_ _02106_ rf\[29\]\[4\] _03121_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__mux2_1
X_05543_ _02048_ rf\[25\]\[31\] _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__mux2_1
X_08185__242 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__inv_2
X_05474_ _02432_ _02536_ VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__nand2_4
X_07213_ _03704_ _03706_ _03708_ _03710_ _03623_ VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__a221o_1
XFILLER_20_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07144_ _03625_ _03644_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__or2_1
XFILLER_118_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07075_ _03563_ _03568_ _03577_ _03258_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__o211a_2
XFILLER_10_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06026_ rf\[18\]\[22\] _02070_ _02848_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__mux2_1
X_07977_ _03206_ _04434_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__or2_1
XFILLER_75_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09716_ net814 _01688_ VGND VGND VPWR VPWR rf\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_06928_ _03271_ _03437_ _03273_ VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__o21a_1
X_09647_ net745 _01619_ VGND VGND VPWR VPWR rf\[27\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_06859_ _03211_ _03372_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__or2_1
XTAP_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09578_ net676 _01550_ VGND VGND VPWR VPWR rf\[24\]\[28\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_1_0__f__04472_ clknet_0__04472_ VGND VGND VPWR VPWR clknet_1_0__leaf__04472_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_82_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_199 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08348__396 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__inv_2
XFILLER_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_89 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08773__797 clknet_1_1__leaf__04488_ VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__inv_2
XFILLER_78_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08054__117 clknet_1_1__leaf__04449_ VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__inv_2
XFILLER_78_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05190_ _02423_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07900_ _03187_ _04361_ VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__or2_1
XFILLER_111_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0__04466_ _04466_ VGND VGND VPWR VPWR clknet_0__04466_ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07831_ _04282_ _04287_ _04296_ _03258_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__o211a_1
XFILLER_111_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09501_ net599 _01473_ VGND VGND VPWR VPWR rf\[22\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_07762_ _03196_ _04230_ _03205_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__o21a_1
X_04974_ _02312_ VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07693_ _03629_ _04165_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__or2_1
X_06713_ rf\[0\]\[14\] rf\[1\]\[14\] rf\[2\]\[14\] rf\[3\]\[14\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03233_ sky130_fd_sc_hd__mux4_1
X_09432_ net530 _01404_ VGND VGND VPWR VPWR rf\[20\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_06644_ rf\[0\]\[10\] VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__clkbuf_1
X_06575_ _03141_ VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__clkbuf_1
X_09363_ net461 _01335_ VGND VGND VPWR VPWR rf\[18\]\[5\] sky130_fd_sc_hd__dfxtp_1
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05526_ _02102_ rf\[26\]\[6\] _02572_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__mux2_1
X_09294_ net392 _01266_ VGND VGND VPWR VPWR rf\[16\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05457_ _02562_ VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__clkbuf_1
XFILLER_118_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05388_ _02526_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__clkbuf_1
X_07127_ _03625_ _03627_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__or2_1
XFILLER_106_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08077__139 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__inv_2
X_07058_ rf\[4\]\[31\] rf\[5\]\[31\] rf\[6\]\[31\] rf\[7\]\[31\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03561_ sky130_fd_sc_hd__mux4_1
X_06009_ _02849_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__clkbuf_1
XFILLER_48_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_220 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04455_ clknet_0__04455_ VGND VGND VPWR VPWR clknet_1_0__leaf__04455_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_109_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08101__162 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__inv_2
XFILLER_3_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04690_ rf\[19\]\[23\] _02068_ _02154_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__mux2_1
XFILLER_99_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08641__672 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__inv_2
XTAP_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06360_ _03030_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__clkbuf_1
X_05311_ _02486_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__clkbuf_1
X_06291_ _02070_ rf\[14\]\[22\] _02985_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__mux2_1
X_05242_ _02084_ rf\[30\]\[15\] _02434_ VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__mux2_1
Xinput30 wr_data_i[27] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
X_08756__781 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__inv_2
XFILLER_116_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput41 wr_data_i[8] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dlymetal6s2s_1
X_05173_ rf\[9\]\[16\] _02082_ _02399_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__mux2_1
XFILLER_107_28 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09981_ net1079 _01953_ VGND VGND VPWR VPWR rf\[4\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08037__101 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__inv_2
XFILLER_111_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0__04449_ _04449_ VGND VGND VPWR VPWR clknet_0__04449_ sky130_fd_sc_hd__clkbuf_16
X_07814_ rf\[4\]\[4\] rf\[5\]\[4\] rf\[6\]\[4\] rf\[7\]\[4\] _03254_ _03199_ VGND
+ VGND VPWR VPWR _04280_ sky130_fd_sc_hd__mux4_1
XFILLER_72_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07745_ rf\[16\]\[0\] rf\[17\]\[0\] rf\[18\]\[0\] rf\[19\]\[0\] _03243_ _03244_ VGND
+ VGND VPWR VPWR _04215_ sky130_fd_sc_hd__mux4_1
X_04957_ rf\[10\]\[25\] _02064_ _02297_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__mux2_1
X_07676_ _04143_ _04145_ _04147_ _04149_ _03622_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__a221o_1
X_09415_ net513 _01387_ VGND VGND VPWR VPWR rf\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04888_ rf\[6\]\[26\] _02062_ _02262_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__mux2_1
X_06627_ _03167_ VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09346_ net444 _01318_ VGND VGND VPWR VPWR rf\[17\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_06558_ _02072_ rf\[29\]\[21\] _03122_ VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__mux2_1
X_05509_ _02589_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__clkbuf_1
X_06489_ _03097_ VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09277_ net375 _01249_ VGND VGND VPWR VPWR rf\[15\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08124__184 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__inv_2
XFILLER_122_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10052_ net143 _02024_ VGND VGND VPWR VPWR rf\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08664__694 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__inv_2
XFILLER_43_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_437 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05860_ _02771_ VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__clkbuf_1
XFILLER_94_632 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05791_ _02100_ rf\[22\]\[7\] _02711_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__mux2_1
XFILLER_93_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04811_ _02227_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__clkbuf_1
XFILLER_35_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04742_ rf\[4\]\[31\] _02048_ _02190_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__mux2_1
X_07530_ _03625_ _04010_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__or2_1
X_07461_ _03579_ _03945_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__or2_1
X_04673_ _02153_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__buf_12
XFILLER_22_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07392_ _03629_ _03879_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__or2_1
XFILLER_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09200_ net298 _01172_ VGND VGND VPWR VPWR rf\[13\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_06412_ rf\[12\]\[28\] _02058_ _03054_ VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__mux2_1
X_09131_ net229 _01103_ VGND VGND VPWR VPWR rf\[29\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_06343_ _02056_ rf\[13\]\[29\] _03019_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__mux2_1
X_08951__966 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1078 sky130_fd_sc_hd__inv_2
X_06274_ _02986_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__clkbuf_1
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05225_ _02442_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__clkbuf_1
X_05156_ _02406_ VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09964_ net1062 _01936_ VGND VGND VPWR VPWR rf\[5\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_05087_ rf\[8\]\[26\] _02062_ _02365_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__mux2_1
XFILLER_57_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09895_ net993 _01867_ VGND VGND VPWR VPWR rf\[10\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_698 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05989_ _02838_ VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__clkbuf_1
X_07728_ rf\[16\]\[31\] rf\[17\]\[31\] rf\[18\]\[31\] rf\[19\]\[31\] _03662_ _03605_
+ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__mux4_1
X_07659_ rf\[12\]\[28\] rf\[13\]\[28\] rf\[14\]\[28\] rf\[15\]\[28\] _03589_ _03584_
+ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__mux4_2
XFILLER_41_702 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09329_ net427 _01301_ VGND VGND VPWR VPWR rf\[17\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08887__905 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1017 sky130_fd_sc_hd__inv_2
XFILLER_122_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10035_ net1133 _02007_ VGND VGND VPWR VPWR rf\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_84_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05010_ _02330_ VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__buf_12
XFILLER_125_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06961_ _03195_ _03468_ VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__or2_1
X_05912_ rf\[20\]\[13\] _02088_ _02780_ VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__mux2_1
X_09680_ net778 _01652_ VGND VGND VPWR VPWR rf\[28\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06892_ rf\[16\]\[22\] rf\[17\]\[22\] rf\[18\]\[22\] rf\[19\]\[22\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__mux4_1
X_08003__70 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__inv_2
XFILLER_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05843_ _02086_ rf\[21\]\[14\] _02745_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__mux2_1
X_08680__709 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__inv_2
X_05774_ _02727_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04725_ _02180_ VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__clkbuf_1
X_07513_ _03988_ _03990_ _03992_ _03994_ _03608_ VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__a221o_2
X_07444_ _03588_ _03929_ _03693_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__o21a_1
XFILLER_62_381 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04656_ _02144_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__clkbuf_1
X_08795__818 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__inv_2
XFILLER_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04587_ _02105_ VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_13_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07375_ _03625_ _03863_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__or2_1
XFILLER_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09114_ net212 _01086_ VGND VGND VPWR VPWR rf\[29\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_06326_ _03012_ VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__clkbuf_1
X_06257_ _02102_ rf\[15\]\[6\] _02951_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__mux2_1
X_05208_ _02049_ _02432_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__nand2_4
X_06188_ rf\[16\]\[7\] _02100_ _02916_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__mux2_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05139_ rf\[8\]\[0\] _02114_ _02364_ VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__mux2_1
XFILLER_104_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_610 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09947_ net1045 _01919_ VGND VGND VPWR VPWR rf\[5\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09878_ net976 _01850_ VGND VGND VPWR VPWR rf\[10\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08440__482 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__inv_2
XFILLER_119_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08555__591 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__inv_2
XFILLER_110_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10018_ net1116 _01990_ VGND VGND VPWR VPWR rf\[19\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04510_ net34 VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__buf_12
X_05490_ _02066_ rf\[26\]\[24\] _02572_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__mux2_1
XFILLER_32_565 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07160_ rf\[16\]\[2\] rf\[17\]\[2\] rf\[18\]\[2\] rf\[19\]\[2\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03660_ sky130_fd_sc_hd__mux4_1
X_06111_ _02901_ VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__clkbuf_1
X_07091_ _03588_ _03592_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__or2_1
XFILLER_117_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06042_ rf\[18\]\[14\] _02086_ _02848_ VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__mux2_1
X_09801_ net899 _01773_ VGND VGND VPWR VPWR rf\[9\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09732_ net830 _01704_ VGND VGND VPWR VPWR rf\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06944_ _03188_ _03450_ _03452_ _03203_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__o211a_1
X_09663_ net761 _01635_ VGND VGND VPWR VPWR rf\[27\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06875_ rf\[0\]\[21\] rf\[1\]\[21\] rf\[2\]\[21\] rf\[3\]\[21\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _03388_ sky130_fd_sc_hd__mux4_1
X_05826_ _02754_ VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__clkbuf_1
X_09594_ net692 _01566_ VGND VGND VPWR VPWR rf\[25\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05757_ _02066_ rf\[22\]\[24\] _02711_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__mux2_1
XFILLER_63_690 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05688_ _02683_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__clkbuf_1
X_04708_ rf\[19\]\[14\] _02086_ _02154_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__mux2_1
XFILLER_23_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07427_ _03913_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
XFILLER_11_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08918__934 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1046 sky130_fd_sc_hd__inv_2
X_04639_ rf\[3\]\[15\] _02084_ _02119_ VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__mux2_1
XFILLER_109_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07358_ _03588_ _03847_ _03597_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__o21a_1
XFILLER_7_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06309_ _02088_ rf\[14\]\[13\] _02985_ VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__mux2_1
XFILLER_108_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07289_ rf\[4\]\[8\] rf\[5\]\[8\] rf\[6\]\[8\] rf\[7\]\[8\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _03783_ sky130_fd_sc_hd__mux4_2
XFILLER_108_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08778__802 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__inv_2
XTAP_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08750__776 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04451_ clknet_0__04451_ VGND VGND VPWR VPWR clknet_1_1__leaf__04451_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_123_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04482_ _04482_ VGND VGND VPWR VPWR clknet_0__04482_ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04990_ _02320_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 port2_reg_i[0] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_08826__847 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__inv_2
XFILLER_76_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06660_ rf\[0\]\[2\] VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__clkbuf_1
X_05611_ _02643_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__clkbuf_1
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06591_ _03149_ VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__clkbuf_1
X_05542_ _02606_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__clkbuf_16
X_08330_ clknet_1_1__leaf__04457_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__buf_1
X_08146__205 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__inv_2
XFILLER_51_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05473_ _02570_ VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07212_ _03699_ _03709_ _03693_ VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__o21a_1
XFILLER_9_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07143_ rf\[12\]\[1\] rf\[13\]\[1\] rf\[14\]\[1\] rf\[15\]\[1\] _03604_ _03613_ VGND
+ VGND VPWR VPWR _03644_ sky130_fd_sc_hd__mux4_1
XFILLER_118_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07074_ _03570_ _03572_ _03574_ _03576_ _03231_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__a221o_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06025_ _02857_ VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08686__715 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__inv_2
XFILLER_101_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07976_ rf\[20\]\[12\] rf\[21\]\[12\] rf\[22\]\[12\] rf\[23\]\[12\] _03190_ _03263_
+ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__mux4_1
XFILLER_87_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09715_ net813 _01687_ VGND VGND VPWR VPWR rf\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06927_ rf\[4\]\[24\] rf\[5\]\[24\] rf\[6\]\[24\] rf\[7\]\[24\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _03437_ sky130_fd_sc_hd__mux4_1
X_09646_ net744 _01618_ VGND VGND VPWR VPWR rf\[27\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06858_ rf\[24\]\[20\] rf\[25\]\[20\] rf\[26\]\[20\] rf\[27\]\[20\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__mux4_1
XFILLER_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09577_ net675 _01549_ VGND VGND VPWR VPWR rf\[24\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_05809_ _02048_ rf\[21\]\[31\] _02745_ VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__mux2_1
Xclkbuf_1_0__f__04471_ clknet_0__04471_ VGND VGND VPWR VPWR clknet_1_0__leaf__04471_
+ sky130_fd_sc_hd__clkbuf_16
X_06789_ rf\[16\]\[17\] rf\[17\]\[17\] rf\[18\]\[17\] rf\[19\]\[17\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__mux4_1
XTAP_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08309__359 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__inv_2
XTAP_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08849__869 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__inv_2
XFILLER_120_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_101 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08594__628 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__inv_2
XFILLER_111_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0__04465_ _04465_ VGND VGND VPWR VPWR clknet_0__04465_ sky130_fd_sc_hd__clkbuf_16
X_07830_ _04289_ _04291_ _04293_ _04295_ _03231_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__a221o_1
XFILLER_96_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07761_ rf\[28\]\[1\] rf\[29\]\[1\] rf\[30\]\[1\] rf\[31\]\[1\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04230_ sky130_fd_sc_hd__mux4_1
XFILLER_110_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09500_ net598 _01472_ VGND VGND VPWR VPWR rf\[22\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_06712_ _03204_ _03217_ _03220_ _03232_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__o211a_1
XFILLER_65_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04973_ rf\[10\]\[17\] _02080_ _02297_ VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__mux2_1
XFILLER_112_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07692_ rf\[24\]\[29\] rf\[25\]\[29\] rf\[26\]\[29\] rf\[27\]\[29\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__mux4_1
X_09431_ net529 _01403_ VGND VGND VPWR VPWR rf\[20\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_06643_ _03175_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__clkbuf_1
X_06574_ _02088_ rf\[29\]\[13\] _03122_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__mux2_1
X_09362_ net460 _01334_ VGND VGND VPWR VPWR rf\[18\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_05525_ _02597_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__clkbuf_1
X_09293_ net391 _01265_ VGND VGND VPWR VPWR rf\[15\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_693 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05456_ _02098_ rf\[27\]\[8\] _02538_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__mux2_1
XFILLER_118_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05387_ _02096_ rf\[28\]\[9\] _02503_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__mux2_1
XFILLER_21_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07126_ rf\[20\]\[1\] rf\[21\]\[1\] rf\[22\]\[1\] rf\[23\]\[1\] _03582_ _03626_ VGND
+ VGND VPWR VPWR _03627_ sky130_fd_sc_hd__mux4_2
XFILLER_4_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07057_ rf\[0\]\[31\] rf\[1\]\[31\] rf\[2\]\[31\] rf\[3\]\[31\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03560_ sky130_fd_sc_hd__mux4_1
X_06008_ rf\[18\]\[31\] _02048_ _02848_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__mux2_1
XFILLER_101_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07959_ rf\[0\]\[11\] rf\[1\]\[11\] rf\[2\]\[11\] rf\[3\]\[11\] _03212_ _03213_ VGND
+ VGND VPWR VPWR _04418_ sky130_fd_sc_hd__mux4_2
XFILLER_90_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09629_ net727 _01601_ VGND VGND VPWR VPWR rf\[26\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f__04454_ clknet_0__04454_ VGND VGND VPWR VPWR clknet_1_0__leaf__04454_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_11_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_708 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_608 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05310_ rf\[2\]\[14\] _02086_ _02468_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__mux2_1
X_06290_ _02994_ VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__clkbuf_1
X_05241_ _02450_ VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__clkbuf_1
X_09053__1 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__inv_2
Xinput20 wr_data_i[18] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput31 wr_data_i[28] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_2
XFILLER_116_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08717__744 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__inv_2
Xinput42 wr_data_i[9] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dlymetal6s2s_1
X_05172_ _02414_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__clkbuf_1
XFILLER_115_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09980_ net1078 _01952_ VGND VGND VPWR VPWR rf\[4\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_115_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__04448_ _04448_ VGND VGND VPWR VPWR clknet_0__04448_ sky130_fd_sc_hd__clkbuf_16
X_07813_ rf\[0\]\[4\] rf\[1\]\[4\] rf\[2\]\[4\] rf\[3\]\[4\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04279_ sky130_fd_sc_hd__mux4_1
X_07744_ _03205_ _04211_ _04213_ _03216_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__a31o_1
XFILLER_37_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04956_ _02303_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__clkbuf_1
X_07675_ _03699_ _04148_ _03693_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__o21a_1
X_08462__503 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__inv_2
XFILLER_80_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09414_ net512 _01386_ VGND VGND VPWR VPWR rf\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_06626_ rf\[0\]\[19\] VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__clkbuf_1
X_04887_ _02267_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09345_ net443 _01317_ VGND VGND VPWR VPWR rf\[17\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_06557_ _03132_ VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__clkbuf_1
X_05508_ _02084_ rf\[26\]\[15\] _02572_ VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__mux2_1
X_08577__612 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__inv_2
X_06488_ rf\[11\]\[23\] net26 _03088_ VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__mux2_1
X_09276_ net374 _01248_ VGND VGND VPWR VPWR rf\[15\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05439_ _02553_ VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08089_ clknet_1_0__leaf__04446_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__buf_1
X_07109_ _03585_ net9 _03610_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__or3_1
XFILLER_121_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10051_ net142 _02023_ VGND VGND VPWR VPWR rf\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08625__657 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__inv_2
XFILLER_71_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_630 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_140 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_600 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_162 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08485__525 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__inv_2
X_05790_ _02735_ VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__clkbuf_1
X_04810_ rf\[5\]\[31\] _02048_ _02226_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__mux2_1
XFILLER_94_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04741_ _02189_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__buf_12
XFILLER_62_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07460_ rf\[24\]\[17\] rf\[25\]\[17\] rf\[26\]\[17\] rf\[27\]\[17\] _03695_ _03696_
+ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__mux4_1
XFILLER_62_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04672_ _02116_ _02152_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__nor2_8
XFILLER_22_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07391_ rf\[16\]\[14\] rf\[17\]\[14\] rf\[18\]\[14\] rf\[19\]\[14\] _03630_ _03631_
+ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__mux4_1
X_06411_ _03057_ VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__clkbuf_1
X_09130_ net228 _01102_ VGND VGND VPWR VPWR rf\[29\]\[28\] sky130_fd_sc_hd__dfxtp_2
X_06342_ _03021_ VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__clkbuf_1
X_08108__169 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__inv_2
XFILLER_30_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06273_ _02048_ rf\[14\]\[31\] _02985_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__mux2_1
XFILLER_116_510 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05224_ _02066_ rf\[30\]\[24\] _02434_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__mux2_1
X_08912__929 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1041 sky130_fd_sc_hd__inv_2
X_05155_ rf\[9\]\[25\] _02064_ _02399_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__mux2_1
XFILLER_89_416 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09963_ net1061 _01935_ VGND VGND VPWR VPWR rf\[5\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_05086_ _02370_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__clkbuf_1
XTAP_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09894_ net992 _01866_ VGND VGND VPWR VPWR rf\[10\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08648__679 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__inv_2
X_07727_ _03625_ _04197_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__or2_1
X_05988_ rf\[1\]\[8\] _02098_ _02814_ VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__mux2_1
XFILLER_65_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04939_ _02293_ VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__clkbuf_1
X_07658_ _04118_ _04123_ _04132_ _03612_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__o211a_2
XFILLER_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_714 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07589_ _03603_ _04066_ VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__or2_1
XFILLER_43_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06609_ _03158_ VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__clkbuf_1
X_09328_ net426 _01300_ VGND VGND VPWR VPWR rf\[17\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_43_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_460 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09259_ net357 _01231_ VGND VGND VPWR VPWR rf\[14\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08393__438 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__inv_2
XFILLER_4_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10034_ net1132 _02006_ VGND VGND VPWR VPWR rf\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_80 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_600 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06960_ rf\[12\]\[26\] rf\[13\]\[26\] rf\[14\]\[26\] rf\[15\]\[26\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__mux4_2
X_05911_ _02798_ VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__clkbuf_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06891_ _03205_ _03400_ _03402_ _03216_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__a31o_1
X_05842_ _02762_ VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05773_ _02082_ rf\[22\]\[16\] _02711_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__mux2_1
XFILLER_47_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04724_ rf\[19\]\[6\] _02102_ _02154_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__mux2_1
X_07512_ _03699_ _03993_ _03682_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__o21a_1
X_07443_ rf\[28\]\[16\] rf\[29\]\[16\] rf\[30\]\[16\] rf\[31\]\[16\] _03646_ _03600_
+ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__mux4_2
XFILLER_62_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04655_ rf\[3\]\[7\] _02100_ _02119_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__mux2_1
XFILLER_22_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09113_ net211 _01085_ VGND VGND VPWR VPWR rf\[29\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_04586_ _02104_ rf\[31\]\[5\] _02051_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__mux2_1
XFILLER_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07374_ rf\[12\]\[13\] rf\[13\]\[13\] rf\[14\]\[13\] rf\[15\]\[13\] _03599_ _03600_
+ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__mux4_1
X_06325_ _02104_ rf\[14\]\[5\] _02984_ VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__mux2_1
XFILLER_30_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06256_ _02976_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__clkbuf_1
X_05207_ net44 _02259_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__nor2_8
X_06187_ _02940_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__clkbuf_1
X_08353__400 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__inv_2
X_05138_ _02396_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__clkbuf_1
X_05069_ rf\[7\]\[2\] _02110_ _02330_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__mux2_1
X_09946_ net1044 _01918_ VGND VGND VPWR VPWR rf\[5\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09877_ net975 _01849_ VGND VGND VPWR VPWR rf\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08516__554 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__inv_2
XFILLER_122_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09040__43 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__inv_2
XFILLER_95_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10017_ net1115 _01989_ VGND VGND VPWR VPWR rf\[19\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08980__993 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1105 sky130_fd_sc_hd__inv_2
XFILLER_91_455 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_680 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08261__313 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__inv_2
XFILLER_32_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06110_ rf\[17\]\[13\] _02088_ _02882_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__mux2_1
X_07090_ rf\[4\]\[0\] rf\[5\]\[0\] rf\[6\]\[0\] rf\[7\]\[0\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03592_ sky130_fd_sc_hd__mux4_1
X_08376__422 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__inv_2
X_06041_ _02865_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09800_ net898 _01772_ VGND VGND VPWR VPWR rf\[9\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06943_ _03247_ _03451_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__or2_1
X_09731_ net829 _01703_ VGND VGND VPWR VPWR rf\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_09662_ net760 _01634_ VGND VGND VPWR VPWR rf\[27\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06874_ _03206_ _03386_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__or2_1
X_05825_ _02068_ rf\[21\]\[23\] _02745_ VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__mux2_1
X_09593_ net691 _01565_ VGND VGND VPWR VPWR rf\[25\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05756_ _02718_ VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__clkbuf_1
XTAP_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08803__826 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__inv_2
X_04707_ _02171_ VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__clkbuf_1
X_05687_ _02062_ rf\[23\]\[26\] _02677_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__mux2_1
XFILLER_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08424__467 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__inv_2
X_04638_ _02135_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__clkbuf_1
X_07426_ _03612_ _03903_ _03912_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__and3_4
XFILLER_50_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07357_ rf\[28\]\[12\] rf\[29\]\[12\] rf\[30\]\[12\] rf\[31\]\[12\] _03583_ _03585_
+ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__mux4_1
X_04569_ _02093_ VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__clkbuf_1
X_06308_ _03003_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__clkbuf_1
X_08539__576 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__inv_2
X_07288_ _03603_ _03781_ VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__or2_1
XFILLER_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06239_ _02084_ rf\[15\]\[15\] _02951_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__mux2_1
XFILLER_104_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09929_ net1027 _01901_ VGND VGND VPWR VPWR rf\[6\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_135 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08284__335 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__inv_2
XTAP_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08399__444 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__inv_2
XFILLER_108_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04450_ clknet_0__04450_ VGND VGND VPWR VPWR clknet_1_1__leaf__04450_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04481_ _04481_ VGND VGND VPWR VPWR clknet_0__04481_ sky130_fd_sc_hd__clkbuf_16
X_08711__739 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__inv_2
XFILLER_123_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_514 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput7 port2_reg_i[1] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_4
X_05610_ rf\[24\]\[31\] _02048_ _02642_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__mux2_1
XFILLER_91_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08447__489 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__inv_2
XFILLER_91_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06590_ _02104_ rf\[29\]\[5\] _03121_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__mux2_1
X_05541_ _02605_ _02536_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__nand2_4
X_05472_ _02114_ rf\[27\]\[0\] _02537_ VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__mux2_1
X_07211_ rf\[28\]\[4\] rf\[29\]\[4\] rf\[30\]\[4\] rf\[31\]\[4\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _03709_ sky130_fd_sc_hd__mux4_1
XFILLER_118_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07142_ _03603_ _03642_ _03595_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__o21a_1
X_07073_ _03196_ _03575_ _03265_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__o21a_1
X_06024_ rf\[18\]\[23\] _02068_ _02848_ VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__mux2_1
XFILLER_113_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08192__248 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__inv_2
XFILLER_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07975_ _03205_ _04430_ _04432_ _03216_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__a31o_2
XFILLER_101_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09714_ net812 _01686_ VGND VGND VPWR VPWR rf\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_400 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06926_ _03261_ _03435_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__or2_1
X_09645_ net743 _01617_ VGND VGND VPWR VPWR rf\[26\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_06857_ _03247_ _03370_ _03273_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__o21a_1
XFILLER_55_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05808_ _02744_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__clkbuf_16
XFILLER_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09576_ net674 _01548_ VGND VGND VPWR VPWR rf\[24\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_1_0__f__04470_ clknet_0__04470_ VGND VGND VPWR VPWR clknet_1_0__leaf__04470_
+ sky130_fd_sc_hd__clkbuf_16
X_06788_ _03206_ _03304_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__or2_1
XFILLER_82_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05739_ _02114_ rf\[23\]\[0\] _02676_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__mux2_1
XTAP_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07409_ _03587_ _03895_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__or2_1
XFILLER_109_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_385 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08871__890 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__inv_2
XFILLER_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04502_ clknet_0__04502_ VGND VGND VPWR VPWR clknet_1_1__leaf__04502_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_6_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0__04464_ _04464_ VGND VGND VPWR VPWR clknet_0__04464_ sky130_fd_sc_hd__clkbuf_16
X_07760_ _03188_ _04228_ VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__or2_1
X_04972_ _02311_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__clkbuf_1
X_08152__210 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__inv_2
XFILLER_110_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06711_ _03223_ _03225_ _03227_ _03229_ _03231_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__a221o_1
XFILLER_112_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09430_ net528 _01402_ VGND VGND VPWR VPWR rf\[20\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_07691_ _03598_ _04163_ _03682_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__o21a_1
XFILLER_80_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06642_ rf\[0\]\[11\] VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__clkbuf_1
X_06573_ _03140_ VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__clkbuf_1
X_09361_ net459 _01333_ VGND VGND VPWR VPWR rf\[18\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05524_ _02100_ rf\[26\]\[7\] _02572_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__mux2_1
X_09292_ net390 _01264_ VGND VGND VPWR VPWR rf\[15\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_33_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05455_ _02561_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__clkbuf_1
X_05386_ _02525_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__clkbuf_1
X_07125_ net7 VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__buf_12
X_07056_ _03545_ _03550_ _03559_ _03258_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__o211a_2
X_06007_ _02847_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__buf_12
XFILLER_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08315__364 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__inv_2
X_08809__832 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__inv_2
XFILLER_47_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07958_ _03206_ _04416_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__or2_1
X_06909_ _03196_ _03419_ _03205_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__o21a_1
X_07889_ _03231_ _04342_ _04351_ _03258_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__o211a_1
XFILLER_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09628_ net726 _01600_ VGND VGND VPWR VPWR rf\[26\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09559_ net657 _01531_ VGND VGND VPWR VPWR rf\[24\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_43_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f__04453_ clknet_0__04453_ VGND VGND VPWR VPWR clknet_1_0__leaf__04453_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_11_311 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_18 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08855__874 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__inv_2
X_08060__123 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__inv_2
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08175__232 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__inv_2
XFILLER_93_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08602__636 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__inv_2
XTAP_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05240_ _02082_ rf\[30\]\[16\] _02434_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__mux2_1
Xinput10 port2_reg_i[4] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_4
Xinput21 wr_data_i[19] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dlymetal6s2s_1
X_08223__277 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__inv_2
Xinput43 wr_en_i VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_4
Xinput32 wr_data_i[29] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
X_05171_ rf\[9\]\[17\] _02080_ _02399_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__mux2_1
XFILLER_116_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08338__386 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__inv_2
XFILLER_123_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07812_ _04264_ _04269_ _04278_ _03258_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__o211a_2
Xclkbuf_0__04447_ _04447_ VGND VGND VPWR VPWR clknet_0__04447_ sky130_fd_sc_hd__clkbuf_16
XFILLER_97_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08792_ clknet_1_0__leaf__04479_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__buf_1
X_07743_ _03211_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__or2_1
X_04955_ rf\[10\]\[26\] _02062_ _02297_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__mux2_1
X_07674_ rf\[28\]\[28\] rf\[29\]\[28\] rf\[30\]\[28\] rf\[31\]\[28\] _03691_ _03626_
+ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__mux4_2
XFILLER_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04886_ rf\[6\]\[27\] _02060_ _02262_ VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__mux2_1
XFILLER_37_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09413_ net511 _01385_ VGND VGND VPWR VPWR rf\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_06625_ _03166_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09344_ net442 _01316_ VGND VGND VPWR VPWR rf\[17\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06556_ _02070_ rf\[29\]\[22\] _03122_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__mux2_1
X_08878__896 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1008 sky130_fd_sc_hd__inv_2
X_05507_ _02588_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__clkbuf_1
X_09275_ net373 _01247_ VGND VGND VPWR VPWR rf\[15\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_08083__145 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__inv_2
X_06487_ _03096_ VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05438_ _02080_ rf\[27\]\[17\] _02538_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__mux2_1
XFILLER_20_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05369_ _02078_ rf\[28\]\[18\] _02503_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__mux2_1
X_08198__254 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__inv_2
X_07108_ net10 _03582_ _03578_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__or3_1
XFILLER_0_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07039_ rf\[4\]\[30\] rf\[5\]\[30\] rf\[6\]\[30\] rf\[7\]\[30\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03543_ sky130_fd_sc_hd__mux4_1
X_10050_ net141 _02022_ VGND VGND VPWR VPWR rf\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_08510__549 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__inv_2
XFILLER_113_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08246__299 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__inv_2
XFILLER_12_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_52 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08015__80 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__inv_2
XFILLER_94_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08030__94 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__inv_2
XFILLER_47_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04740_ _02187_ _02188_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__nor2_8
X_04671_ net47 net46 net48 VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__or3b_4
X_06410_ rf\[12\]\[29\] _02056_ _03054_ VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__mux2_1
X_07390_ _03699_ _03877_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__or2_1
XFILLER_62_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06341_ _02054_ rf\[13\]\[30\] _03019_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__mux2_1
X_06272_ _02984_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__clkbuf_16
X_05223_ _02441_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05154_ _02405_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__clkbuf_1
X_05085_ rf\[8\]\[27\] _02060_ _02365_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__mux2_1
X_09962_ net1060 _01934_ VGND VGND VPWR VPWR rf\[5\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_08913_ clknet_1_1__leaf__04490_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__buf_1
XFILLER_69_130 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09893_ net991 _01865_ VGND VGND VPWR VPWR rf\[10\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05987_ _02837_ VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__clkbuf_1
X_07726_ rf\[20\]\[31\] rf\[21\]\[31\] rf\[22\]\[31\] rf\[23\]\[31\] _03582_ _03626_
+ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__mux4_2
XFILLER_27_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04938_ rf\[6\]\[1\] _02112_ _02261_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__mux2_1
X_07657_ _04125_ _04127_ _04129_ _04131_ _03623_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__a221o_1
XFILLER_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04869_ _02256_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__clkbuf_1
X_07588_ rf\[8\]\[24\] rf\[9\]\[24\] rf\[10\]\[24\] rf\[11\]\[24\] _03604_ _03613_
+ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__mux4_1
XFILLER_41_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06608_ rf\[0\]\[28\] VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__clkbuf_1
X_09327_ net425 _01299_ VGND VGND VPWR VPWR rf\[17\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_06539_ _03123_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09258_ net356 _01230_ VGND VGND VPWR VPWR rf\[14\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08209_ clknet_1_1__leaf__04443_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__buf_1
X_09189_ net287 _01161_ VGND VGND VPWR VPWR rf\[12\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_104_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10033_ net1131 _02005_ VGND VGND VPWR VPWR rf\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05910_ rf\[20\]\[14\] _02086_ _02780_ VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__mux2_1
XFILLER_67_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06890_ _03211_ _03401_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__or2_1
X_05841_ _02084_ rf\[21\]\[15\] _02745_ VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__mux2_1
XFILLER_67_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08608__642 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__inv_2
X_05772_ _02726_ VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08114__174 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__inv_2
X_08491_ clknet_1_1__leaf__04468_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__buf_1
X_04723_ _02179_ VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07511_ rf\[4\]\[20\] rf\[5\]\[20\] rf\[6\]\[20\] rf\[7\]\[20\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _03993_ sky130_fd_sc_hd__mux4_2
XFILLER_50_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07442_ _03629_ _03927_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__or2_1
X_04654_ _02143_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_22_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07373_ _03580_ _03859_ _03861_ _03595_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__o211a_1
X_08229__283 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__inv_2
X_09112_ net210 _01084_ VGND VGND VPWR VPWR rf\[29\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_04585_ net38 VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__buf_12
X_06324_ _03011_ VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06255_ _02100_ rf\[15\]\[7\] _02951_ VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__mux2_1
X_06186_ rf\[16\]\[8\] _02098_ _02916_ VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__mux2_1
X_05206_ _02431_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__clkbuf_1
X_08654__684 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__inv_2
X_05137_ rf\[8\]\[1\] _02112_ _02364_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__mux2_1
XFILLER_104_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05068_ _02360_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__clkbuf_1
X_09945_ net1043 _01917_ VGND VGND VPWR VPWR rf\[5\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_09876_ net974 _01848_ VGND VGND VPWR VPWR rf\[10\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07709_ rf\[8\]\[30\] rf\[9\]\[30\] rf\[10\]\[30\] rf\[11\]\[30\] _03662_ _03605_
+ VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__mux4_1
XFILLER_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08401__446 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__inv_2
XFILLER_5_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10016_ net1114 _01988_ VGND VGND VPWR VPWR rf\[19\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_08137__196 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__inv_2
XFILLER_49_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08941__956 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1068 sky130_fd_sc_hd__inv_2
XFILLER_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06040_ rf\[18\]\[15\] _02084_ _02848_ VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__mux2_1
XFILLER_125_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09730_ net828 _01702_ VGND VGND VPWR VPWR rf\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_06942_ rf\[4\]\[25\] rf\[5\]\[25\] rf\[6\]\[25\] rf\[7\]\[25\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03451_ sky130_fd_sc_hd__mux4_1
X_09661_ net759 _01633_ VGND VGND VPWR VPWR rf\[27\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_82_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06873_ rf\[4\]\[21\] rf\[5\]\[21\] rf\[6\]\[21\] rf\[7\]\[21\] _03243_ _03244_ VGND
+ VGND VPWR VPWR _03386_ sky130_fd_sc_hd__mux4_1
X_09592_ net690 _01564_ VGND VGND VPWR VPWR rf\[25\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_05824_ _02753_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__clkbuf_1
X_08612_ clknet_1_1__leaf__04479_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__buf_1
XFILLER_94_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05755_ _02064_ rf\[22\]\[25\] _02711_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__mux2_1
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04706_ rf\[19\]\[15\] _02084_ _02154_ VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__mux2_1
X_05686_ _02682_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__clkbuf_1
X_07425_ _03905_ _03907_ _03909_ _03911_ _03622_ VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__a221o_1
X_04637_ rf\[3\]\[16\] _02082_ _02119_ VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__mux2_1
XFILLER_11_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07356_ _03580_ _03845_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__or2_1
X_04568_ _02092_ rf\[31\]\[11\] _02052_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__mux2_1
XFILLER_109_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06307_ _02086_ rf\[14\]\[14\] _02985_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__mux2_1
X_07287_ rf\[0\]\[8\] rf\[1\]\[8\] rf\[2\]\[8\] rf\[3\]\[8\] _03604_ _03613_ VGND
+ VGND VPWR VPWR _03781_ sky130_fd_sc_hd__mux4_1
X_06238_ _02967_ VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__clkbuf_1
X_06169_ _02931_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__clkbuf_1
X_09928_ net1026 _01900_ VGND VGND VPWR VPWR rf\[6\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_79 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08964__978 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1090 sky130_fd_sc_hd__inv_2
X_09859_ net957 _01831_ VGND VGND VPWR VPWR rf\[7\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0__04480_ _04480_ VGND VGND VPWR VPWR clknet_0__04480_ sky130_fd_sc_hd__clkbuf_16
XFILLER_123_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput8 port2_reg_i[2] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_64_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05540_ net45 _02223_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__nor2_8
X_05471_ _02569_ VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__clkbuf_1
X_07210_ _03579_ _03707_ VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__or2_1
XFILLER_20_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07141_ rf\[0\]\[1\] rf\[1\]\[1\] rf\[2\]\[1\] rf\[3\]\[1\] _03599_ _03600_ VGND
+ VGND VPWR VPWR _03642_ sky130_fd_sc_hd__mux4_1
X_07072_ rf\[28\]\[31\] rf\[29\]\[31\] rf\[30\]\[31\] rf\[31\]\[31\] _03254_ _03208_
+ VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__mux4_1
XFILLER_114_631 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06023_ _02856_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__clkbuf_1
XFILLER_10_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07974_ _03211_ _04431_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__or2_1
X_09713_ net811 _01685_ VGND VGND VPWR VPWR rf\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_19_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06925_ rf\[0\]\[24\] rf\[1\]\[24\] rf\[2\]\[24\] rf\[3\]\[24\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _03435_ sky130_fd_sc_hd__mux4_1
X_06856_ rf\[20\]\[20\] rf\[21\]\[20\] rf\[22\]\[20\] rf\[23\]\[20\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__mux4_1
X_09644_ net742 _01616_ VGND VGND VPWR VPWR rf\[26\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08924__940 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1052 sky130_fd_sc_hd__inv_2
X_05807_ _02605_ _02675_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__nand2_4
XFILLER_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09575_ net673 _01547_ VGND VGND VPWR VPWR rf\[24\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_06787_ rf\[20\]\[17\] rf\[21\]\[17\] rf\[22\]\[17\] rf\[23\]\[17\] _03190_ _03263_
+ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__mux4_1
XTAP_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05738_ _02708_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__clkbuf_1
X_05669_ _02672_ VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07408_ rf\[12\]\[15\] rf\[13\]\[15\] rf\[14\]\[15\] rf\[15\]\[15\] _03589_ _03584_
+ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__mux4_1
XFILLER_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07339_ _03603_ _03829_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__or2_1
XFILLER_105_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_648 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08407__452 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__inv_2
X_08999__1011 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1123 sky130_fd_sc_hd__inv_2
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f__04501_ clknet_0__04501_ VGND VGND VPWR VPWR clknet_1_1__leaf__04501_
+ sky130_fd_sc_hd__clkbuf_16
X_08832__853 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__inv_2
XFILLER_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08453__494 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__inv_2
XFILLER_110_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0__04463_ _04463_ VGND VGND VPWR VPWR clknet_0__04463_ sky130_fd_sc_hd__clkbuf_16
XFILLER_69_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08947__962 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1074 sky130_fd_sc_hd__inv_2
XFILLER_2_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04971_ rf\[10\]\[18\] _02078_ _02297_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__mux2_1
XFILLER_110_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06710_ _03230_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__clkbuf_16
XFILLER_77_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07690_ rf\[20\]\[29\] rf\[21\]\[29\] rf\[22\]\[29\] rf\[23\]\[29\] _03662_ _03605_
+ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__mux4_1
XFILLER_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06641_ _03174_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_18_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06572_ _02086_ rf\[29\]\[14\] _03122_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__mux2_1
X_09360_ net458 _01332_ VGND VGND VPWR VPWR rf\[18\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_05523_ _02596_ VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__clkbuf_1
X_09291_ net389 _01263_ VGND VGND VPWR VPWR rf\[15\]\[29\] sky130_fd_sc_hd__dfxtp_2
XFILLER_33_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05454_ _02096_ rf\[27\]\[9\] _02538_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__mux2_1
XFILLER_118_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05385_ _02094_ rf\[28\]\[10\] _02503_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__mux2_1
X_07124_ _03587_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__buf_6
X_07055_ _03552_ _03554_ _03556_ _03558_ _03231_ VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__a221o_1
X_06006_ _02152_ _02260_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__nor2_4
X_08200__256 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__inv_2
XFILLER_114_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07957_ rf\[4\]\[11\] rf\[5\]\[11\] rf\[6\]\[11\] rf\[7\]\[11\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _04416_ sky130_fd_sc_hd__mux4_2
X_06908_ rf\[28\]\[23\] rf\[29\]\[23\] rf\[30\]\[23\] rf\[31\]\[23\] _03191_ _03193_
+ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__mux4_1
XFILLER_56_710 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07888_ _04344_ _04346_ _04348_ _04350_ _03216_ VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__a221o_2
X_06839_ rf\[24\]\[19\] rf\[25\]\[19\] rf\[26\]\[19\] rf\[27\]\[19\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__mux4_1
X_09627_ net725 _01599_ VGND VGND VPWR VPWR rf\[26\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09558_ net656 _01530_ VGND VGND VPWR VPWR rf\[24\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_08740__766 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__inv_2
Xclkbuf_1_0__f__04452_ clknet_0__04452_ VGND VGND VPWR VPWR clknet_1_0__leaf__04452_
+ sky130_fd_sc_hd__clkbuf_16
X_09489_ net587 _01461_ VGND VGND VPWR VPWR rf\[22\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08816__837 clknet_1_1__leaf__04491_ VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__inv_2
XFILLER_125_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_467 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08676__705 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__inv_2
XFILLER_14_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput22 wr_data_i[1] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput11 wr_data_i[0] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput33 wr_data_i[2] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput44 wr_reg_i[0] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_4
X_05170_ _02413_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07811_ _04271_ _04273_ _04275_ _04277_ _03231_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__a221o_1
Xclkbuf_0__04446_ _04446_ VGND VGND VPWR VPWR clknet_0__04446_ sky130_fd_sc_hd__clkbuf_16
X_04954_ _02302_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__clkbuf_1
X_07742_ rf\[8\]\[0\] rf\[9\]\[0\] rf\[10\]\[0\] rf\[11\]\[0\] _03212_ _03221_ VGND
+ VGND VPWR VPWR _04212_ sky130_fd_sc_hd__mux4_1
X_07673_ _03578_ _04146_ VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__or2_1
X_08763__788 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__inv_2
XFILLER_16_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04885_ _02266_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__clkbuf_1
X_09412_ net510 _01384_ VGND VGND VPWR VPWR rf\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_06624_ rf\[0\]\[20\] VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__clkbuf_1
XFILLER_16_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09343_ net441 _01315_ VGND VGND VPWR VPWR rf\[17\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06555_ _03131_ VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05506_ _02082_ rf\[26\]\[16\] _02572_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__mux2_1
X_06486_ rf\[11\]\[24\] net27 _03088_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__mux2_1
X_09274_ net372 _01246_ VGND VGND VPWR VPWR rf\[15\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_08839__859 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__inv_2
X_05437_ _02552_ VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__clkbuf_1
X_08044__108 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__inv_2
X_05368_ _02516_ VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__clkbuf_1
X_07107_ _03597_ _03602_ _03607_ _03608_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__a31o_1
X_05299_ _02480_ VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__clkbuf_1
X_08159__217 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__inv_2
X_07038_ rf\[0\]\[30\] rf\[1\]\[30\] rf\[2\]\[30\] rf\[3\]\[30\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03542_ sky130_fd_sc_hd__mux4_1
X_08998__1010 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1122 sky130_fd_sc_hd__inv_2
XFILLER_48_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08699__727 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__inv_2
XFILLER_43_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_603 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07999__66 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__inv_2
XFILLER_125_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_407 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04670_ _02151_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__clkbuf_1
X_08723__750 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__inv_2
XFILLER_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06340_ _03020_ VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__clkbuf_1
X_06271_ _02432_ _02949_ VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__nand2_4
XFILLER_30_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05222_ _02064_ rf\[30\]\[25\] _02434_ VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__mux2_1
X_05153_ rf\[9\]\[26\] _02062_ _02399_ VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__mux2_1
XFILLER_116_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05084_ _02369_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__clkbuf_1
X_09961_ net1059 _01933_ VGND VGND VPWR VPWR rf\[5\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09892_ net990 _01864_ VGND VGND VPWR VPWR rf\[10\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05986_ rf\[1\]\[9\] _02096_ _02814_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__mux2_1
XFILLER_26_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04937_ _02292_ VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__clkbuf_1
X_07725_ _03595_ _04189_ _04191_ _04193_ _04195_ VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__a32o_1
XFILLER_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07656_ _03588_ _04130_ _03693_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__o21a_1
XFILLER_53_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04868_ rf\[5\]\[2\] _02110_ _02225_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__mux2_1
XFILLER_80_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06607_ _03157_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__clkbuf_1
X_04799_ _02219_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07587_ _03625_ _04064_ VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__or2_1
X_09326_ net424 _01298_ VGND VGND VPWR VPWR rf\[17\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_06538_ _02048_ rf\[29\]\[31\] _03122_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__mux2_1
X_09257_ net355 _01229_ VGND VGND VPWR VPWR rf\[14\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06469_ _03086_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__clkbuf_1
X_08206__262 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__inv_2
XFILLER_5_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09188_ net286 _01160_ VGND VGND VPWR VPWR rf\[12\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_08631__663 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__inv_2
XFILLER_102_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10032_ net1130 _02004_ VGND VGND VPWR VPWR rf\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08746__772 clknet_1_1__leaf__04486_ VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__inv_2
XFILLER_29_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_638 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_510 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_537 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_570 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05840_ _02761_ VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__clkbuf_1
XFILLER_94_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05771_ _02080_ rf\[22\]\[17\] _02711_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__mux2_1
X_07510_ _03579_ _03991_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__or2_1
X_04722_ rf\[19\]\[7\] _02100_ _02154_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__mux2_1
X_07441_ rf\[24\]\[16\] rf\[25\]\[16\] rf\[26\]\[16\] rf\[27\]\[16\] _03630_ _03613_
+ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__mux4_1
XFILLER_90_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04653_ rf\[3\]\[8\] _02098_ _02119_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__mux2_1
X_07372_ _03598_ _03860_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__or2_1
X_04584_ _02103_ VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__clkbuf_1
X_09111_ net209 _01083_ VGND VGND VPWR VPWR rf\[29\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_06323_ _02102_ rf\[14\]\[6\] _02985_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__mux2_1
X_06254_ _02975_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__clkbuf_1
X_06185_ _02939_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__clkbuf_1
X_05205_ rf\[9\]\[0\] _02114_ _02398_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__mux2_1
XFILLER_116_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08615__647 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__inv_2
X_05136_ _02395_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09944_ net1042 _01916_ VGND VGND VPWR VPWR rf\[5\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_05067_ rf\[7\]\[3\] _02108_ _02330_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__mux2_1
X_09875_ net973 _01847_ VGND VGND VPWR VPWR rf\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_08769__794 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__inv_2
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05969_ _02828_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__clkbuf_1
XTAP_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07708_ _03625_ _04179_ VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__or2_1
X_07639_ _04114_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
X_09309_ net407 _01281_ VGND VGND VPWR VPWR rf\[16\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_68 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08475__515 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__inv_2
XFILLER_79_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10015_ net1113 _01987_ VGND VGND VPWR VPWR rf\[19\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08902__919 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1031 sky130_fd_sc_hd__inv_2
XFILLER_91_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08562__598 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__inv_2
X_08638__669 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__inv_2
X_09016__20 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__inv_2
XFILLER_113_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06941_ rf\[0\]\[25\] rf\[1\]\[25\] rf\[2\]\[25\] rf\[3\]\[25\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03450_ sky130_fd_sc_hd__mux4_1
X_09660_ net758 _01632_ VGND VGND VPWR VPWR rf\[27\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06872_ _03203_ _03378_ _03380_ _03382_ _03384_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__a32o_1
X_08611_ clknet_1_0__leaf__04443_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__buf_1
XFILLER_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09591_ net689 _01563_ VGND VGND VPWR VPWR rf\[25\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_05823_ _02066_ rf\[21\]\[24\] _02745_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__mux2_1
X_05754_ _02717_ VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04705_ _02170_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05685_ _02060_ rf\[23\]\[27\] _02677_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__mux2_1
X_07424_ _03699_ _03910_ _03693_ VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__o21a_1
XFILLER_23_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04636_ _02134_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08498__537 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__inv_2
X_07355_ rf\[24\]\[12\] rf\[25\]\[12\] rf\[26\]\[12\] rf\[27\]\[12\] _03590_ _03585_
+ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__mux4_1
XFILLER_10_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04567_ net13 VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__buf_12
XFILLER_109_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07286_ _03603_ _03779_ _03693_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__o21a_1
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06306_ _03002_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__clkbuf_1
X_06237_ _02082_ rf\[15\]\[16\] _02951_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__mux2_1
XFILLER_117_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06168_ rf\[16\]\[17\] _02080_ _02916_ VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__mux2_1
X_06099_ _02895_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__clkbuf_1
X_05119_ rf\[8\]\[10\] _02094_ _02365_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__mux2_1
XFILLER_49_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09927_ net1025 _01899_ VGND VGND VPWR VPWR rf\[6\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_24 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09858_ net956 _01830_ VGND VGND VPWR VPWR rf\[7\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09789_ net887 _01761_ VGND VGND VPWR VPWR rf\[9\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08522__560 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__inv_2
XFILLER_41_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08785__809 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__inv_2
XFILLER_122_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 port2_reg_i[3] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_8
XFILLER_36_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05470_ _02112_ rf\[27\]\[1\] _02537_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__mux2_1
XFILLER_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07140_ _03625_ _03640_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__or2_1
X_07071_ _03242_ _03573_ VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__or2_1
X_06022_ rf\[18\]\[24\] _02066_ _02848_ VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__mux2_1
XFILLER_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09712_ net810 _01684_ VGND VGND VPWR VPWR rf\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_07973_ rf\[8\]\[12\] rf\[9\]\[12\] rf\[10\]\[12\] rf\[11\]\[12\] _03212_ _03221_
+ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__mux4_1
X_06924_ _03261_ _03433_ _03265_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__o21a_1
X_08430__473 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__inv_2
X_09643_ net741 _01615_ VGND VGND VPWR VPWR rf\[26\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06855_ _03242_ _03368_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__or2_2
X_05806_ _02743_ VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__clkbuf_1
X_09574_ net672 _01546_ VGND VGND VPWR VPWR rf\[24\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_06786_ _03289_ _03294_ _03303_ _03258_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__o211a_1
XTAP_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08545__582 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__inv_2
X_05737_ _02112_ rf\[23\]\[1\] _02676_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__mux2_1
XFILLER_82_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05668_ rf\[24\]\[2\] _02110_ _02641_ VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__mux2_1
X_07407_ _03623_ _03885_ _03894_ _03650_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__o211a_1
X_04619_ rf\[3\]\[25\] _02064_ _02119_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__mux2_1
XFILLER_11_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05599_ _02108_ rf\[25\]\[3\] _02606_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__mux2_1
XFILLER_109_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07338_ rf\[8\]\[11\] rf\[9\]\[11\] rf\[10\]\[11\] rf\[11\]\[11\] _03604_ _03605_
+ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__mux4_1
XFILLER_7_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07269_ _03603_ _03763_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__or2_1
XFILLER_120_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08251__303 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__inv_2
XFILLER_59_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04500_ clknet_0__04500_ VGND VGND VPWR VPWR clknet_1_1__leaf__04500_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_51_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0__04462_ _04462_ VGND VGND VPWR VPWR clknet_0__04462_ sky130_fd_sc_hd__clkbuf_16
X_08414__457 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__inv_2
X_08908__925 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1037 sky130_fd_sc_hd__inv_2
XFILLER_65_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04970_ _02310_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__clkbuf_1
XFILLER_49_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06640_ rf\[0\]\[12\] VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__clkbuf_1
XFILLER_2_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_574 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06571_ _03139_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__clkbuf_1
XFILLER_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05522_ _02098_ rf\[26\]\[8\] _02572_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__mux2_1
X_08310_ clknet_1_0__leaf__04457_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__buf_1
X_09290_ net388 _01262_ VGND VGND VPWR VPWR rf\[15\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_05453_ _02560_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05384_ _02524_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__clkbuf_1
XFILLER_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07123_ _03596_ _03609_ _03612_ _03624_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__o211a_1
XFILLER_118_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07054_ _03196_ _03557_ _03265_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__o21a_1
Xoutput110 net110 VGND VGND VPWR VPWR port2_data_o[7] sky130_fd_sc_hd__buf_2
X_08274__325 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__inv_2
X_06005_ _02846_ VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07956_ _03203_ _04408_ _04410_ _04412_ _04414_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__a32o_1
X_06907_ _03188_ _03417_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__or2_1
XFILLER_56_722 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07887_ _03196_ _04349_ _03203_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__o21a_1
X_09626_ net724 _01598_ VGND VGND VPWR VPWR rf\[26\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06838_ _03247_ _03352_ _03273_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__o21a_1
XFILLER_83_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09557_ net655 _01529_ VGND VGND VPWR VPWR rf\[24\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_1_0__f__04451_ clknet_0__04451_ VGND VGND VPWR VPWR clknet_1_0__leaf__04451_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_24_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06769_ rf\[4\]\[16\] rf\[5\]\[16\] rf\[6\]\[16\] rf\[7\]\[16\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03287_ sky130_fd_sc_hd__mux4_1
X_09488_ net586 _01460_ VGND VGND VPWR VPWR rf\[22\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_62_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08701__729 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__inv_2
XFILLER_70_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08437__479 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__inv_2
XFILLER_120_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_700 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_479 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput12 wr_data_i[10] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_30_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput45 wr_reg_i[1] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_4
Xinput23 wr_data_i[20] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput34 wr_data_i[30] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_2
X_08297__347 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__inv_2
XFILLER_111_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07810_ _03196_ _04276_ _03265_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__o21a_1
Xclkbuf_0__04445_ _04445_ VGND VGND VPWR VPWR clknet_0__04445_ sky130_fd_sc_hd__clkbuf_16
X_07741_ _03206_ _04210_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__or2_1
XFILLER_65_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04953_ rf\[10\]\[27\] _02060_ _02297_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__mux2_1
X_07672_ rf\[24\]\[28\] rf\[25\]\[28\] rf\[26\]\[28\] rf\[27\]\[28\] _03589_ _03584_
+ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__mux4_1
X_04884_ rf\[6\]\[28\] _02058_ _02262_ VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__mux2_1
XFILLER_92_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06623_ _03165_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__clkbuf_1
X_09411_ net509 _01383_ VGND VGND VPWR VPWR rf\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_09342_ net440 _01314_ VGND VGND VPWR VPWR rf\[17\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_06554_ _02068_ rf\[29\]\[23\] _03122_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__mux2_1
XFILLER_80_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05505_ _02587_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__clkbuf_1
X_06485_ _03095_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__clkbuf_1
X_09273_ net371 _01245_ VGND VGND VPWR VPWR rf\[15\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_33_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05436_ _02078_ rf\[27\]\[18\] _02538_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__mux2_1
XFILLER_21_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05367_ _02076_ rf\[28\]\[19\] _02503_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__mux2_1
XFILLER_119_576 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08321__370 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__inv_2
XFILLER_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07106_ net10 VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__clkbuf_16
X_05298_ rf\[2\]\[20\] _02074_ _02468_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__mux2_1
X_07037_ _03541_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
XFILLER_102_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_515 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08584__619 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__inv_2
XFILLER_87_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_711 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07939_ _03261_ _04398_ VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__or2_1
XFILLER_56_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09609_ net707 _01581_ VGND VGND VPWR VPWR rf\[25\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08861__880 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__inv_2
XFILLER_28_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_717 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_599 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08344__392 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__inv_2
XFILLER_8_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06270_ _02983_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__clkbuf_1
X_05221_ _02440_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__clkbuf_1
X_05152_ _02404_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05083_ rf\[8\]\[28\] _02058_ _02365_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__mux2_1
X_09960_ net1058 _01932_ VGND VGND VPWR VPWR rf\[5\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09891_ net989 _01863_ VGND VGND VPWR VPWR rf\[10\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05985_ _02836_ VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04936_ rf\[6\]\[2\] _02110_ _02261_ VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__mux2_1
X_08050__113 clknet_1_1__leaf__04449_ VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__inv_2
X_07724_ _03580_ _04194_ _03597_ VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__o21a_1
X_07655_ rf\[28\]\[27\] rf\[29\]\[27\] rf\[30\]\[27\] rf\[31\]\[27\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__mux4_2
XFILLER_26_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06606_ rf\[0\]\[29\] VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__clkbuf_1
X_04867_ _02255_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__clkbuf_1
X_04798_ rf\[4\]\[3\] _02108_ _02189_ VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__mux2_1
XFILLER_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07586_ rf\[12\]\[24\] rf\[13\]\[24\] rf\[14\]\[24\] rf\[15\]\[24\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__mux4_1
X_09325_ net423 _01297_ VGND VGND VPWR VPWR rf\[16\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06537_ _03121_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__buf_12
X_06468_ rf\[12\]\[0\] _02114_ _03053_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__mux2_1
X_09256_ net354 _01228_ VGND VGND VPWR VPWR rf\[14\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_05419_ _02543_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09037__40 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__inv_2
XFILLER_5_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06399_ _02112_ rf\[13\]\[1\] _03018_ VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__mux2_1
X_09187_ net285 _01159_ VGND VGND VPWR VPWR rf\[12\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_08069_ clknet_1_1__leaf__04446_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__buf_1
XFILLER_103_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10031_ net1129 _02003_ VGND VGND VPWR VPWR rf\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08707__735 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__inv_2
XFILLER_29_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08213__267 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__inv_2
XFILLER_44_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08567__603 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__inv_2
X_08073__135 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__inv_2
XFILLER_39_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_582 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05770_ _02725_ VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__clkbuf_1
XFILLER_94_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04721_ _02178_ VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_706 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07440_ _03598_ _03925_ _03682_ VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__o21a_1
X_04652_ _02142_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__clkbuf_1
X_04583_ _02102_ rf\[31\]\[6\] _02052_ VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__mux2_1
X_07371_ rf\[4\]\[13\] rf\[5\]\[13\] rf\[6\]\[13\] rf\[7\]\[13\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03860_ sky130_fd_sc_hd__mux4_1
X_09110_ net208 _01082_ VGND VGND VPWR VPWR rf\[29\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_06322_ _03010_ VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__clkbuf_1
X_08500__539 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__inv_2
X_06253_ _02098_ rf\[15\]\[8\] _02951_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__mux2_1
X_06184_ rf\[16\]\[9\] _02096_ _02916_ VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__mux2_1
X_05204_ _02430_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05135_ rf\[8\]\[2\] _02110_ _02364_ VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__mux2_1
XFILLER_89_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05066_ _02359_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__clkbuf_1
X_09943_ net1041 _01915_ VGND VGND VPWR VPWR rf\[5\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_09874_ net972 _01846_ VGND VGND VPWR VPWR rf\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08236__289 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__inv_2
XFILLER_38_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05968_ rf\[1\]\[18\] _02078_ _02814_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__mux2_1
XFILLER_26_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05899_ _02792_ VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__clkbuf_1
XFILLER_72_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04919_ _02283_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__clkbuf_1
XFILLER_26_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07707_ rf\[12\]\[30\] rf\[13\]\[30\] rf\[14\]\[30\] rf\[15\]\[30\] _03582_ _03626_
+ VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__mux4_1
X_07638_ _03612_ _04104_ _04113_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__and3_4
X_07569_ rf\[28\]\[23\] rf\[29\]\[23\] rf\[30\]\[23\] rf\[31\]\[23\] _03583_ _03585_
+ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__mux4_2
X_08360__407 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__inv_2
X_09308_ net406 _01280_ VGND VGND VPWR VPWR rf\[16\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_09239_ net337 _01211_ VGND VGND VPWR VPWR rf\[14\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08096__157 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__inv_2
XFILLER_95_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10014_ net1112 _01986_ VGND VGND VPWR VPWR rf\[19\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_514 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08120__180 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__inv_2
X_06940_ _03449_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
X_09031__35 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__inv_2
X_06871_ _03196_ _03383_ _03205_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__o21a_1
X_05822_ _02752_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__clkbuf_1
XFILLER_67_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09590_ net688 _01562_ VGND VGND VPWR VPWR rf\[25\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05753_ _02062_ rf\[22\]\[26\] _02711_ VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__mux2_1
X_05684_ _02681_ VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__clkbuf_1
X_08383__429 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__inv_2
X_04704_ rf\[19\]\[16\] _02082_ _02154_ VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__mux2_1
XFILLER_63_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07423_ rf\[28\]\[15\] rf\[29\]\[15\] rf\[30\]\[15\] rf\[31\]\[15\] _03691_ _03626_
+ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__mux4_2
XFILLER_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04635_ rf\[3\]\[17\] _02080_ _02119_ VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__mux2_1
XFILLER_50_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08660__690 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__inv_2
XFILLER_11_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07354_ _03629_ _03843_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__or2_1
X_04566_ _02091_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07285_ rf\[8\]\[8\] rf\[9\]\[8\] rf\[10\]\[8\] rf\[11\]\[8\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _03779_ sky130_fd_sc_hd__mux4_1
X_06305_ _02084_ rf\[14\]\[15\] _02985_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__mux2_1
X_06236_ _02966_ VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06167_ _02930_ VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06098_ rf\[17\]\[19\] _02076_ _02882_ VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__mux2_1
X_05118_ _02386_ VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__clkbuf_1
X_05049_ rf\[7\]\[12\] _02090_ _02331_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__mux2_1
X_09926_ net1024 _01898_ VGND VGND VPWR VPWR rf\[6\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09857_ net955 _01829_ VGND VGND VPWR VPWR rf\[7\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09788_ net886 _01760_ VGND VGND VPWR VPWR rf\[9\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_322 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08219__273 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__inv_2
XFILLER_1_484 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09056__4 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__inv_2
XFILLER_55_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07070_ rf\[24\]\[31\] rf\[25\]\[31\] rf\[26\]\[31\] rf\[27\]\[31\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__mux4_1
XFILLER_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06021_ _02855_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__clkbuf_1
X_08079__141 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__inv_2
XFILLER_101_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08883__901 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1013 sky130_fd_sc_hd__inv_2
XFILLER_114_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09711_ net809 _01683_ VGND VGND VPWR VPWR rf\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_07972_ _03206_ _04429_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__or2_1
XFILLER_101_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06923_ rf\[8\]\[24\] rf\[9\]\[24\] rf\[10\]\[24\] rf\[11\]\[24\] _03262_ _03268_
+ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__mux4_1
XFILLER_28_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09642_ net740 _01614_ VGND VGND VPWR VPWR rf\[26\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06854_ rf\[16\]\[20\] rf\[17\]\[20\] rf\[18\]\[20\] rf\[19\]\[20\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__mux4_1
X_09573_ net671 _01545_ VGND VGND VPWR VPWR rf\[24\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_05805_ _02114_ rf\[22\]\[0\] _02710_ VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__mux2_1
X_06785_ _03296_ _03298_ _03300_ _03302_ _03231_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__a221o_1
XFILLER_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05736_ _02707_ VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__clkbuf_1
XFILLER_70_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08506__545 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__inv_2
X_05667_ _02671_ VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__clkbuf_1
XFILLER_35_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05598_ _02635_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__clkbuf_1
XFILLER_11_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07406_ _03887_ _03889_ _03891_ _03893_ _03608_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__a221o_1
X_04618_ _02125_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04549_ net19 VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__buf_12
X_07337_ _03625_ _03827_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__or2_1
XFILLER_109_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07268_ rf\[24\]\[7\] rf\[25\]\[7\] rf\[26\]\[7\] rf\[27\]\[7\] _03604_ _03613_ VGND
+ VGND VPWR VPWR _03763_ sky130_fd_sc_hd__mux4_2
X_08970__984 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1096 sky130_fd_sc_hd__inv_2
X_07199_ rf\[0\]\[4\] rf\[1\]\[4\] rf\[2\]\[4\] rf\[3\]\[4\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03697_ sky130_fd_sc_hd__mux4_2
X_06219_ _02064_ rf\[15\]\[25\] _02951_ VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__mux2_1
XFILLER_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09909_ net1007 _01881_ VGND VGND VPWR VPWR rf\[6\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_74_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08366__413 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__inv_2
XFILLER_92_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_686 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0__04461_ _04461_ VGND VGND VPWR VPWR clknet_0__04461_ sky130_fd_sc_hd__clkbuf_16
XFILLER_2_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08529__567 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__inv_2
XFILLER_92_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06570_ _02084_ rf\[29\]\[15\] _03122_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__mux2_1
XFILLER_80_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05521_ _02595_ VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__clkbuf_1
X_05452_ _02094_ rf\[27\]\[10\] _02538_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__mux2_1
X_09068__16 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__inv_2
X_08954__968 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1080 sky130_fd_sc_hd__inv_2
X_05383_ _02092_ rf\[28\]\[11\] _02503_ VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__mux2_1
X_07122_ _03615_ _03617_ _03619_ _03621_ _03623_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__a221o_1
Xoutput100 net100 VGND VGND VPWR VPWR port2_data_o[27] sky130_fd_sc_hd__buf_2
X_07053_ rf\[28\]\[30\] rf\[29\]\[30\] rf\[30\]\[30\] rf\[31\]\[30\] _03254_ _03208_
+ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__mux4_1
X_06004_ rf\[1\]\[0\] _02114_ _02813_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__mux2_1
Xoutput111 net111 VGND VGND VPWR VPWR port2_data_o[8] sky130_fd_sc_hd__buf_2
XFILLER_114_463 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_708 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07955_ _03196_ _04413_ _03205_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__o21a_1
X_08389__435 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__inv_2
X_06906_ rf\[24\]\[23\] rf\[25\]\[23\] rf\[26\]\[23\] rf\[27\]\[23\] _03198_ _03193_
+ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__mux4_1
X_09625_ net723 _01597_ VGND VGND VPWR VPWR rf\[26\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_56_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07886_ rf\[4\]\[7\] rf\[5\]\[7\] rf\[6\]\[7\] rf\[7\]\[7\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04349_ sky130_fd_sc_hd__mux4_2
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06837_ rf\[20\]\[19\] rf\[21\]\[19\] rf\[22\]\[19\] rf\[23\]\[19\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__mux4_1
XFILLER_83_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09556_ net654 _01528_ VGND VGND VPWR VPWR rf\[24\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06768_ rf\[0\]\[16\] rf\[1\]\[16\] rf\[2\]\[16\] rf\[3\]\[16\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03286_ sky130_fd_sc_hd__mux4_1
XFILLER_55_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f__04450_ clknet_0__04450_ VGND VGND VPWR VPWR clknet_1_0__leaf__04450_
+ sky130_fd_sc_hd__clkbuf_16
X_09487_ net585 _01459_ VGND VGND VPWR VPWR rf\[22\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_05719_ _02094_ rf\[23\]\[10\] _02677_ VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__mux2_1
XFILLER_102_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06699_ _03219_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__buf_4
XFILLER_24_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_712 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08182__239 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__inv_2
Xinput13 wr_data_i[11] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput46 wr_reg_i[2] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_4
Xinput24 wr_data_i[21] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput35 wr_data_i[31] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_2
X_08914__930 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1042 sky130_fd_sc_hd__inv_2
Xclkbuf_0__04444_ _04444_ VGND VGND VPWR VPWR clknet_0__04444_ sky130_fd_sc_hd__clkbuf_16
XFILLER_111_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04952_ _02301_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__clkbuf_1
X_07740_ rf\[12\]\[0\] rf\[13\]\[0\] rf\[14\]\[0\] rf\[15\]\[0\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04210_ sky130_fd_sc_hd__mux4_1
XFILLER_38_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07671_ _03699_ _04144_ _03594_ VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__o21a_1
XFILLER_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04883_ _02265_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__clkbuf_1
XFILLER_65_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09410_ net508 _01382_ VGND VGND VPWR VPWR rf\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_06622_ rf\[0\]\[21\] VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__clkbuf_1
X_09341_ net439 _01313_ VGND VGND VPWR VPWR rf\[17\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_06553_ _03130_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__clkbuf_1
X_05504_ _02080_ rf\[26\]\[17\] _02572_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__mux2_1
XFILLER_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06484_ rf\[11\]\[25\] net28 _03088_ VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__mux2_1
X_09272_ net370 _01244_ VGND VGND VPWR VPWR rf\[15\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05435_ _02551_ VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05366_ _02515_ VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_588 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07105_ _03603_ _03606_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__or2_1
X_07036_ _03220_ _03531_ _03540_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__and3_4
X_05297_ _02479_ VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07938_ rf\[16\]\[10\] rf\[17\]\[10\] rf\[18\]\[10\] rf\[19\]\[10\] _03190_ _03263_
+ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__mux4_1
XFILLER_29_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07869_ _04326_ _04328_ _04330_ _04332_ _03231_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__a221o_1
XFILLER_28_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09608_ net706 _01580_ VGND VGND VPWR VPWR rf\[25\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_25 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04502_ clknet_0__04502_ VGND VGND VPWR VPWR clknet_1_0__leaf__04502_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_16_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08822__843 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__inv_2
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09539_ net637 _01511_ VGND VGND VPWR VPWR rf\[23\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08937__952 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1064 sky130_fd_sc_hd__inv_2
XFILLER_11_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08142__201 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__inv_2
XFILLER_22_51 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_689 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08682__711 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__inv_2
XFILLER_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08797__820 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__inv_2
XFILLER_62_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05220_ _02062_ rf\[30\]\[26\] _02434_ VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__mux2_1
X_08305__355 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__inv_2
XFILLER_8_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05151_ rf\[9\]\[27\] _02060_ _02399_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__mux2_1
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05082_ _02368_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__clkbuf_1
XFILLER_69_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09890_ net988 _01862_ VGND VGND VPWR VPWR rf\[10\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05984_ rf\[1\]\[10\] _02094_ _02814_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__mux2_1
XTAP_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08845__865 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__inv_2
X_08772_ clknet_1_0__leaf__04479_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__buf_1
XFILLER_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08021__86 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__inv_2
X_04935_ _02291_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__clkbuf_1
X_07723_ rf\[8\]\[31\] rf\[9\]\[31\] rf\[10\]\[31\] rf\[11\]\[31\] _03590_ _03585_
+ VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__mux4_1
X_07654_ _03629_ _04128_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__or2_1
XFILLER_26_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06605_ _03156_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__clkbuf_1
X_04866_ rf\[5\]\[3\] _02108_ _02225_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__mux2_1
X_04797_ _02218_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07585_ _03580_ _04060_ _04062_ _03595_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__o211a_1
X_09324_ net422 _01296_ VGND VGND VPWR VPWR rf\[16\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_06536_ _02049_ _02605_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__nand2_4
XFILLER_21_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08165__223 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__inv_2
X_06467_ _03085_ VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__clkbuf_1
X_09255_ net353 _01227_ VGND VGND VPWR VPWR rf\[14\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_05418_ _02060_ rf\[27\]\[27\] _02538_ VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__mux2_1
X_06398_ _03049_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__clkbuf_1
X_09186_ net284 _01158_ VGND VGND VPWR VPWR rf\[12\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05349_ _02058_ rf\[28\]\[28\] _02503_ VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__mux2_1
XFILLER_108_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09052__55 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__inv_2
XFILLER_68_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07019_ _03195_ _03523_ VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__or2_1
X_10030_ net1128 _02002_ VGND VGND VPWR VPWR rf\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08328__377 clknet_1_1__leaf__04463_ VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__inv_2
XFILLER_12_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08753__778 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__inv_2
XFILLER_113_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08868__887 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__inv_2
XFILLER_121_594 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04720_ rf\[19\]\[8\] _02098_ _02154_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__mux2_1
X_08188__245 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__inv_2
X_04651_ rf\[3\]\[9\] _02096_ _02119_ VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__mux2_1
XFILLER_23_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07370_ rf\[0\]\[13\] rf\[1\]\[13\] rf\[2\]\[13\] rf\[3\]\[13\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03859_ sky130_fd_sc_hd__mux4_1
X_04582_ net39 VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__buf_12
X_06321_ _02100_ rf\[14\]\[7\] _02985_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__mux2_1
X_06252_ _02974_ VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__clkbuf_1
X_05203_ rf\[9\]\[1\] _02112_ _02398_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__mux2_1
X_06183_ _02938_ VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__clkbuf_1
X_05134_ _02394_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__clkbuf_1
X_05065_ rf\[7\]\[4\] _02106_ _02330_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__mux2_1
X_09942_ net1040 _01914_ VGND VGND VPWR VPWR rf\[5\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09873_ net971 _01845_ VGND VGND VPWR VPWR rf\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07706_ _03595_ _04171_ _04173_ _04175_ _04177_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__a32o_1
X_05967_ _02827_ VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__clkbuf_1
XFILLER_26_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05898_ rf\[20\]\[20\] _02074_ _02780_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__mux2_1
XFILLER_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04918_ rf\[6\]\[11\] _02092_ _02262_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__mux2_1
XFILLER_26_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07637_ _04106_ _04108_ _04110_ _04112_ _03622_ VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__a221o_1
XFILLER_81_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04849_ _02246_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__clkbuf_1
XFILLER_110_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07568_ _03580_ _04046_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__or2_1
X_09307_ net405 _01279_ VGND VGND VPWR VPWR rf\[16\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_06519_ _03112_ VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__clkbuf_1
X_07499_ rf\[0\]\[19\] rf\[1\]\[19\] rf\[2\]\[19\] rf\[3\]\[19\] _03630_ _03613_ VGND
+ VGND VPWR VPWR _03982_ sky130_fd_sc_hd__mux4_1
X_09238_ net336 _01210_ VGND VGND VPWR VPWR rf\[14\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09169_ net267 _01141_ VGND VGND VPWR VPWR rf\[12\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_08713__740 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__inv_2
XFILLER_79_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10013_ net1111 _01985_ VGND VGND VPWR VPWR rf\[19\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_272 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08000__67 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__inv_2
XFILLER_32_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_526 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06870_ rf\[28\]\[21\] rf\[29\]\[21\] rf\[30\]\[21\] rf\[31\]\[21\] _03191_ _03193_
+ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__mux4_1
X_05821_ _02064_ rf\[21\]\[25\] _02745_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__mux2_1
XFILLER_121_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05752_ _02716_ VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__clkbuf_1
XFILLER_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05683_ _02058_ rf\[23\]\[28\] _02677_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__mux2_1
X_08471_ clknet_1_1__leaf__04468_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__buf_1
X_04703_ _02169_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07422_ _03579_ _03908_ VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__or2_1
X_04634_ _02133_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__clkbuf_1
X_08621__653 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__inv_2
X_07353_ rf\[16\]\[12\] rf\[17\]\[12\] rf\[18\]\[12\] rf\[19\]\[12\] _03630_ _03631_
+ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__mux4_1
X_04565_ _02090_ rf\[31\]\[12\] _02052_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__mux2_1
XFILLER_10_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07284_ _03625_ _03777_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__or2_1
X_06304_ _03001_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__clkbuf_1
X_06235_ _02080_ rf\[15\]\[17\] _02951_ VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__mux2_1
X_08736__762 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__inv_2
XFILLER_117_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06166_ rf\[16\]\[18\] _02078_ _02916_ VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__mux2_1
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06097_ _02894_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__clkbuf_1
X_05117_ rf\[8\]\[11\] _02092_ _02365_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__mux2_1
X_05048_ _02350_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__clkbuf_1
X_09925_ net1023 _01897_ VGND VGND VPWR VPWR rf\[6\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09856_ net954 _01828_ VGND VGND VPWR VPWR rf\[7\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06999_ rf\[20\]\[28\] rf\[21\]\[28\] rf\[22\]\[28\] rf\[23\]\[28\] _03190_ _03263_
+ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__mux4_1
X_09787_ net885 _01759_ VGND VGND VPWR VPWR rf\[9\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08481__521 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__inv_2
XTAP_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_515 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08596__630 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__inv_2
XFILLER_6_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08104__165 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__inv_2
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_111 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08644__675 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__inv_2
XFILLER_32_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_334 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08759__784 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__inv_2
XFILLER_118_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06020_ rf\[18\]\[25\] _02064_ _02848_ VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__mux2_1
XFILLER_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07971_ rf\[12\]\[12\] rf\[13\]\[12\] rf\[14\]\[12\] rf\[15\]\[12\] _03248_ _03213_
+ VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__mux4_1
XFILLER_101_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09710_ net808 _01682_ VGND VGND VPWR VPWR rf\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_06922_ _03195_ _03431_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__or2_4
X_09641_ net739 _01613_ VGND VGND VPWR VPWR rf\[26\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06853_ _03205_ _03364_ _03366_ _03216_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__a31o_1
X_09572_ net670 _01544_ VGND VGND VPWR VPWR rf\[24\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_05804_ _02742_ VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__clkbuf_1
XFILLER_95_595 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06784_ _03196_ _03301_ _03205_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__o21a_1
XFILLER_82_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05735_ _02110_ rf\[23\]\[2\] _02676_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__mux2_1
XFILLER_82_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05666_ rf\[24\]\[3\] _02108_ _02641_ VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__mux2_1
X_05597_ _02106_ rf\[25\]\[4\] _02606_ VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__mux2_1
X_07405_ _03580_ _03892_ _03693_ VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__o21a_1
X_04617_ rf\[3\]\[26\] _02062_ _02119_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__mux2_1
X_04548_ _02079_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__clkbuf_1
X_07336_ rf\[12\]\[11\] rf\[13\]\[11\] rf\[14\]\[11\] rf\[15\]\[11\] _03599_ _03600_
+ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__mux4_1
XFILLER_50_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08127__187 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__inv_2
X_07267_ _03598_ _03761_ _03682_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__o21a_1
X_08931__947 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1059 sky130_fd_sc_hd__inv_2
X_06218_ _02957_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__clkbuf_1
X_07198_ net7 VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__buf_12
X_06149_ _02921_ VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__clkbuf_1
XFILLER_2_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08552__588 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__inv_2
XFILLER_76_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09908_ net1006 _01880_ VGND VGND VPWR VPWR rf\[6\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_74_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09839_ net937 _01811_ VGND VGND VPWR VPWR rf\[7\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08667__697 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__inv_2
XFILLER_46_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08791__815 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__inv_2
XFILLER_10_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_595 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0__04460_ _04460_ VGND VGND VPWR VPWR clknet_0__04460_ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05520_ _02096_ rf\[26\]\[9\] _02572_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__mux2_1
X_05451_ _02559_ VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05382_ _02523_ VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__clkbuf_1
X_07121_ _03622_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__buf_8
XFILLER_9_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput101 net101 VGND VGND VPWR VPWR port2_data_o[28] sky130_fd_sc_hd__buf_4
X_07052_ _03242_ _03555_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__or2_1
X_06003_ _02845_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__clkbuf_1
Xoutput112 net112 VGND VGND VPWR VPWR port2_data_o[9] sky130_fd_sc_hd__buf_4
XFILLER_114_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08512__550 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__inv_2
X_07954_ rf\[28\]\[11\] rf\[29\]\[11\] rf\[30\]\[11\] rf\[31\]\[11\] _03198_ _03193_
+ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04489_ clknet_0__04489_ VGND VGND VPWR VPWR clknet_1_1__leaf__04489_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_101_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06905_ _03242_ _03415_ VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__or2_1
X_07885_ _03242_ _04347_ VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__or2_1
X_09624_ net722 _01596_ VGND VGND VPWR VPWR rf\[26\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06836_ _03242_ _03350_ VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__or2_1
XFILLER_83_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06767_ _03285_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
X_09555_ net653 _01527_ VGND VGND VPWR VPWR rf\[24\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_09486_ net584 _01458_ VGND VGND VPWR VPWR rf\[22\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_05718_ _02698_ VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__clkbuf_1
X_06698_ _03193_ net4 _03218_ VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__or3_1
X_05649_ _02662_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__clkbuf_1
XFILLER_109_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07319_ rf\[8\]\[10\] rf\[9\]\[10\] rf\[10\]\[10\] rf\[11\]\[10\] _03604_ _03605_
+ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__mux4_1
XFILLER_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08027__92 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__inv_2
XFILLER_101_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_679 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08420__463 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__inv_2
Xinput36 wr_data_i[3] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput14 wr_data_i[12] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput25 wr_data_i[22] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput47 wr_reg_i[3] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_4
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08535__572 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__inv_2
XFILLER_96_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0__04443_ _04443_ VGND VGND VPWR VPWR clknet_0__04443_ sky130_fd_sc_hd__clkbuf_16
XFILLER_69_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04951_ rf\[10\]\[28\] _02058_ _02297_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__mux2_1
XFILLER_38_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07670_ rf\[20\]\[28\] rf\[21\]\[28\] rf\[22\]\[28\] rf\[23\]\[28\] _03695_ _03696_
+ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__mux4_1
X_04882_ rf\[6\]\[29\] _02056_ _02262_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__mux2_1
XFILLER_80_502 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06621_ _03164_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__clkbuf_1
X_09340_ net438 _01312_ VGND VGND VPWR VPWR rf\[17\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_06552_ _02066_ rf\[29\]\[24\] _03122_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__mux2_1
XFILLER_52_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05503_ _02586_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__clkbuf_1
X_09271_ net369 _01243_ VGND VGND VPWR VPWR rf\[15\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_08280__331 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__inv_2
X_06483_ _03094_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__clkbuf_1
X_05434_ _02076_ rf\[27\]\[19\] _02538_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__mux2_1
X_05365_ _02074_ rf\[28\]\[20\] _02503_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__mux2_1
XFILLER_107_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07104_ rf\[8\]\[0\] rf\[9\]\[0\] rf\[10\]\[0\] rf\[11\]\[0\] _03604_ _03605_ VGND
+ VGND VPWR VPWR _03606_ sky130_fd_sc_hd__mux4_1
X_08395__440 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__inv_2
X_07035_ _03533_ _03535_ _03537_ _03539_ _03231_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__a221o_1
X_05296_ rf\[2\]\[21\] _02072_ _02468_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__mux2_1
X_07937_ _03205_ _04394_ _04396_ _03216_ VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__a31o_2
XFILLER_68_381 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07868_ _03196_ _04331_ _03265_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__o21a_1
X_06819_ rf\[24\]\[18\] rf\[25\]\[18\] rf\[26\]\[18\] rf\[27\]\[18\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__mux4_1
XFILLER_113_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09607_ net705 _01579_ VGND VGND VPWR VPWR rf\[25\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07799_ _03206_ _04265_ VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__or2_1
Xclkbuf_1_0__f__04501_ clknet_0__04501_ VGND VGND VPWR VPWR clknet_1_0__leaf__04501_
+ sky130_fd_sc_hd__clkbuf_16
X_09538_ net636 _01510_ VGND VGND VPWR VPWR rf\[23\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_09469_ net567 _01441_ VGND VGND VPWR VPWR rf\[21\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_51_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08443__485 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__inv_2
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08558__594 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__inv_2
XFILLER_121_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_598 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05150_ _02403_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_548 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05081_ rf\[8\]\[29\] _02056_ _02365_ VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__mux2_1
X_08730__757 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__inv_2
XTAP_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_592 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08006__73 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__inv_2
XTAP_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05983_ _02835_ VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__clkbuf_1
X_08351__398 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__inv_2
X_04934_ rf\[6\]\[3\] _02108_ _02261_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__mux2_1
X_07722_ _03588_ _04192_ VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__or2_1
X_07653_ rf\[24\]\[27\] rf\[25\]\[27\] rf\[26\]\[27\] rf\[27\]\[27\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__mux4_1
X_04865_ _02254_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__clkbuf_1
XFILLER_80_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06604_ rf\[0\]\[30\] VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__clkbuf_1
XFILLER_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09323_ net421 _01295_ VGND VGND VPWR VPWR rf\[16\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_04796_ rf\[4\]\[4\] _02106_ _02189_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__mux2_1
X_07584_ _03598_ _04061_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__or2_1
X_06535_ _03120_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06466_ rf\[12\]\[1\] _02112_ _03053_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__mux2_1
X_09254_ net352 _01226_ VGND VGND VPWR VPWR rf\[14\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_05417_ _02542_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__clkbuf_1
X_09185_ net283 _01157_ VGND VGND VPWR VPWR rf\[12\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06397_ _02110_ rf\[13\]\[2\] _03018_ VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__mux2_1
X_08590__625 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__inv_2
X_05348_ _02506_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__clkbuf_1
XFILLER_4_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05279_ _02470_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__clkbuf_1
X_07018_ rf\[12\]\[29\] rf\[13\]\[29\] rf\[14\]\[29\] rf\[15\]\[29\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__mux4_2
XFILLER_103_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_638 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10089_ net125 _01037_ VGND VGND VPWR VPWR rf\[31\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_08311__360 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__inv_2
XFILLER_35_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04650_ _02141_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__clkbuf_1
X_04581_ _02101_ VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06320_ _03009_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06251_ _02096_ rf\[15\]\[9\] _02951_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__mux2_1
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08574__609 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__inv_2
X_05202_ _02429_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__clkbuf_1
X_06182_ rf\[16\]\[10\] _02094_ _02916_ VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__mux2_1
X_05133_ rf\[8\]\[3\] _02108_ _02364_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__mux2_1
X_08689__718 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__inv_2
X_05064_ _02358_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__clkbuf_1
X_09941_ net1039 _01913_ VGND VGND VPWR VPWR rf\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_09872_ net970 _01844_ VGND VGND VPWR VPWR rf\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05966_ rf\[1\]\[19\] _02076_ _02814_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__mux2_1
XFILLER_57_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07705_ _03588_ _04176_ _03597_ VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__o21a_1
X_04917_ _02282_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__clkbuf_1
XTAP_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05897_ _02791_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07636_ _03699_ _04111_ _03693_ VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__o21a_1
X_04848_ rf\[5\]\[12\] _02090_ _02226_ VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__mux2_1
X_07567_ rf\[24\]\[23\] rf\[25\]\[23\] rf\[26\]\[23\] rf\[27\]\[23\] _03590_ _03591_
+ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__mux4_1
X_04779_ _02209_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__clkbuf_1
X_09306_ net404 _01278_ VGND VGND VPWR VPWR rf\[16\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_06518_ rf\[11\]\[8\] net41 _03088_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__mux2_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09237_ net335 _01209_ VGND VGND VPWR VPWR rf\[14\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_07498_ _03603_ _03980_ _03693_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__o21a_1
X_06449_ _03076_ VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__clkbuf_1
X_09168_ net266 _01140_ VGND VGND VPWR VPWR rf\[12\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09099_ net197 _01071_ VGND VGND VPWR VPWR rf\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_89_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10012_ net1110 _01984_ VGND VGND VPWR VPWR rf\[19\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08334__382 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__inv_2
XFILLER_63_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08449__491 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__inv_2
XFILLER_17_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08874__892 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1004 sky130_fd_sc_hd__inv_2
XFILLER_8_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08194__250 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__inv_2
X_05820_ _02751_ VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__clkbuf_1
XFILLER_94_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05751_ _02060_ rf\[22\]\[27\] _02711_ VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__mux2_1
X_05682_ _02680_ VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__clkbuf_1
X_04702_ rf\[19\]\[17\] _02080_ _02154_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__mux2_1
XFILLER_23_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07421_ rf\[24\]\[15\] rf\[25\]\[15\] rf\[26\]\[15\] rf\[27\]\[15\] _03695_ _03696_
+ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__mux4_1
X_04633_ rf\[3\]\[18\] _02078_ _02119_ VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__mux2_1
X_07352_ _03625_ _03841_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__or2_1
XFILLER_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04564_ net14 VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__buf_12
X_06303_ _02082_ rf\[14\]\[16\] _02985_ VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__mux2_1
X_07283_ rf\[12\]\[8\] rf\[13\]\[8\] rf\[14\]\[8\] rf\[15\]\[8\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03777_ sky130_fd_sc_hd__mux4_1
XFILLER_117_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06234_ _02965_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08242__295 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__inv_2
X_06165_ _02929_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05116_ _02385_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06096_ rf\[17\]\[20\] _02074_ _02882_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__mux2_1
X_09924_ net1022 _01896_ VGND VGND VPWR VPWR rf\[6\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_05047_ rf\[7\]\[13\] _02088_ _02331_ VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__mux2_1
X_09022__26 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__inv_2
XFILLER_98_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09855_ net953 _01827_ VGND VGND VPWR VPWR rf\[7\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06998_ _03490_ _03495_ _03504_ _03258_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__o211a_2
X_09786_ net884 _01758_ VGND VGND VPWR VPWR rf\[9\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05949_ _02818_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__clkbuf_1
XTAP_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07619_ _03623_ _04086_ _04095_ _03650_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__o211a_1
XFILLER_14_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_310 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07970_ _03188_ _04425_ _04427_ _03203_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__o211a_1
XFILLER_101_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06921_ rf\[12\]\[24\] rf\[13\]\[24\] rf\[14\]\[24\] rf\[15\]\[24\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__mux4_2
XFILLER_68_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09640_ net738 _01612_ VGND VGND VPWR VPWR rf\[26\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06852_ _03211_ _03365_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__or2_1
X_09571_ net669 _01543_ VGND VGND VPWR VPWR rf\[24\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_05803_ _02112_ rf\[22\]\[1\] _02710_ VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__mux2_1
X_08465__506 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__inv_2
X_06783_ rf\[28\]\[16\] rf\[29\]\[16\] rf\[30\]\[16\] rf\[31\]\[16\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__mux4_1
X_05734_ _02706_ VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05665_ _02670_ VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__clkbuf_1
XFILLER_90_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07404_ rf\[8\]\[14\] rf\[9\]\[14\] rf\[10\]\[14\] rf\[11\]\[14\] _03646_ _03600_
+ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__mux4_1
X_05596_ _02634_ VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__clkbuf_1
X_04616_ _02124_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_23_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04547_ _02078_ rf\[31\]\[18\] _02052_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__mux2_1
X_07335_ _03580_ _03823_ _03825_ _03595_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__o211a_1
X_07266_ rf\[20\]\[7\] rf\[21\]\[7\] rf\[22\]\[7\] rf\[23\]\[7\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _03761_ sky130_fd_sc_hd__mux4_1
XFILLER_31_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06217_ _02062_ rf\[15\]\[26\] _02951_ VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__mux2_1
X_07197_ _03581_ VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__buf_12
X_06148_ rf\[16\]\[27\] _02060_ _02916_ VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__mux2_1
XFILLER_3_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06079_ _02885_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__clkbuf_1
XFILLER_76_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09907_ net1005 _01879_ VGND VGND VPWR VPWR rf\[6\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09838_ net936 _01810_ VGND VGND VPWR VPWR rf\[7\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_09769_ net867 _01741_ VGND VGND VPWR VPWR rf\[30\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08110__170 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__inv_2
XTAP_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08373__419 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__inv_2
XFILLER_6_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08488__528 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__inv_2
XFILLER_65_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05450_ _02092_ rf\[27\]\[11\] _02538_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__mux2_1
XFILLER_60_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05381_ _02090_ rf\[28\]\[12\] _02503_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__mux2_1
XFILLER_119_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07120_ net10 VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__inv_2
X_07051_ rf\[24\]\[30\] rf\[25\]\[30\] rf\[26\]\[30\] rf\[27\]\[30\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__mux4_1
Xoutput102 net102 VGND VGND VPWR VPWR port2_data_o[29] sky130_fd_sc_hd__buf_2
XFILLER_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06002_ rf\[1\]\[1\] _02112_ _02813_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__mux2_1
XFILLER_102_616 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07953_ _03188_ _04411_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__or2_1
Xclkbuf_1_1__f__04488_ clknet_0__04488_ VGND VGND VPWR VPWR clknet_1_1__leaf__04488_
+ sky130_fd_sc_hd__clkbuf_16
X_06904_ rf\[16\]\[23\] rf\[17\]\[23\] rf\[18\]\[23\] rf\[19\]\[23\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__mux4_1
XFILLER_28_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07884_ rf\[0\]\[7\] rf\[1\]\[7\] rf\[2\]\[7\] rf\[3\]\[7\] _03251_ _03244_ VGND
+ VGND VPWR VPWR _04347_ sky130_fd_sc_hd__mux4_2
X_09623_ net721 _01595_ VGND VGND VPWR VPWR rf\[26\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06835_ rf\[16\]\[19\] rf\[17\]\[19\] rf\[18\]\[19\] rf\[19\]\[19\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__mux4_1
XFILLER_55_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09554_ net652 _01526_ VGND VGND VPWR VPWR rf\[24\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_06766_ _03220_ _03275_ _03284_ VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__and3_4
X_08133__192 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__inv_2
X_09485_ net583 _01457_ VGND VGND VPWR VPWR rf\[21\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_05717_ _02092_ rf\[23\]\[11\] _02677_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__mux2_1
X_06697_ net5 _03190_ _03187_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__or3_1
X_05648_ rf\[24\]\[12\] _02090_ _02642_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__mux2_1
XFILLER_51_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05579_ _02088_ rf\[25\]\[13\] _02607_ VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__mux2_1
X_07318_ _03625_ _03809_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__or2_1
XFILLER_109_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07249_ _03579_ _03744_ VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__or2_1
XFILLER_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput37 wr_data_i[4] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput15 wr_data_i[13] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput26 wr_data_i[23] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_2
Xinput48 wr_reg_i[4] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_4
X_04950_ _02300_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__clkbuf_1
XFILLER_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06620_ rf\[0\]\[22\] VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__clkbuf_1
X_04881_ _02264_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__clkbuf_1
X_08960__974 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1086 sky130_fd_sc_hd__inv_2
XFILLER_80_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06551_ _03129_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__clkbuf_1
X_05502_ _02078_ rf\[26\]\[18\] _02572_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__mux2_1
X_06482_ rf\[11\]\[26\] net29 _03088_ VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__mux2_1
X_09270_ net368 _01242_ VGND VGND VPWR VPWR rf\[15\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_05433_ _02550_ VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__clkbuf_1
XFILLER_60_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05364_ _02514_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__clkbuf_1
X_05295_ _02478_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__clkbuf_1
X_07103_ _03584_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__buf_12
X_07034_ _03271_ _03538_ _03265_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__o21a_1
X_08356__403 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__inv_2
XFILLER_115_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07936_ _03211_ _04395_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__or2_1
XFILLER_68_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07867_ rf\[28\]\[6\] rf\[29\]\[6\] rf\[30\]\[6\] rf\[31\]\[6\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04331_ sky130_fd_sc_hd__mux4_1
XFILLER_68_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09606_ net704 _01578_ VGND VGND VPWR VPWR rf\[25\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_06818_ _03271_ _03333_ _03273_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__o21a_1
XFILLER_83_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04500_ clknet_0__04500_ VGND VGND VPWR VPWR clknet_1_0__leaf__04500_
+ sky130_fd_sc_hd__clkbuf_16
X_07798_ rf\[12\]\[3\] rf\[13\]\[3\] rf\[14\]\[3\] rf\[15\]\[3\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04265_ sky130_fd_sc_hd__mux4_1
XFILLER_44_717 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09537_ net635 _01509_ VGND VGND VPWR VPWR rf\[23\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_06749_ net2 VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__buf_12
XFILLER_73_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08896__913 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1025 sky130_fd_sc_hd__inv_2
X_09468_ net566 _01440_ VGND VGND VPWR VPWR rf\[21\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_09399_ net497 _01371_ VGND VGND VPWR VPWR rf\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_51_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_538 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08519__557 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__inv_2
XFILLER_3_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_356 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08983__996 clknet_1_1__leaf__04499_ VGND VGND VPWR VPWR net1108 sky130_fd_sc_hd__inv_2
XFILLER_47_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08264__316 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__inv_2
XTAP_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08379__425 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__inv_2
XFILLER_30_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05080_ _02367_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_680 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05982_ rf\[1\]\[11\] _02092_ _02814_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__mux2_1
X_04933_ _02290_ VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__clkbuf_1
X_08806__829 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__inv_2
X_07721_ rf\[12\]\[31\] rf\[13\]\[31\] rf\[14\]\[31\] rf\[15\]\[31\] _03590_ _03591_
+ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__mux4_1
XFILLER_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07652_ _03598_ _04126_ _03682_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__o21a_1
X_04864_ rf\[5\]\[4\] _02106_ _02225_ VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__mux2_1
X_07583_ rf\[4\]\[24\] rf\[5\]\[24\] rf\[6\]\[24\] rf\[7\]\[24\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _04061_ sky130_fd_sc_hd__mux4_1
X_06603_ _03155_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__clkbuf_1
X_09322_ net420 _01294_ VGND VGND VPWR VPWR rf\[16\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_04795_ _02217_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__clkbuf_1
X_06534_ rf\[11\]\[0\] net11 _03087_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__mux2_1
XFILLER_33_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06465_ _03084_ VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09253_ net351 _01225_ VGND VGND VPWR VPWR rf\[14\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_05416_ _02058_ rf\[27\]\[28\] _02538_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__mux2_1
X_09184_ net282 _01156_ VGND VGND VPWR VPWR rf\[12\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06396_ _03048_ VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__clkbuf_1
X_05347_ _02056_ rf\[28\]\[29\] _02503_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__mux2_1
XFILLER_107_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05278_ rf\[2\]\[30\] _02054_ _02468_ VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__mux2_1
X_07017_ _03231_ _03513_ _03522_ _03258_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__o211a_2
XFILLER_88_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08172__229 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__inv_2
XFILLER_102_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07919_ rf\[16\]\[9\] rf\[17\]\[9\] rf\[18\]\[9\] rf\[19\]\[9\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _04380_ sky130_fd_sc_hd__mux4_1
X_08012__77 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__inv_2
X_08287__338 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__inv_2
XFILLER_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09028__32 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__inv_2
XFILLER_125_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09043__46 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__inv_2
XFILLER_3_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07995__62 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__inv_2
XFILLER_121_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10088_ net124 _01036_ VGND VGND VPWR VPWR rf\[31\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04580_ _02100_ rf\[31\]\[7\] _02052_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__mux2_1
XFILLER_43_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06250_ _02973_ VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__clkbuf_1
X_05201_ rf\[9\]\[2\] _02110_ _02398_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__mux2_1
X_06181_ _02937_ VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__clkbuf_1
X_08851__871 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__inv_2
X_05132_ _02393_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__clkbuf_1
X_05063_ rf\[7\]\[5\] _02104_ _02330_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__mux2_1
X_09940_ net1038 _01912_ VGND VGND VPWR VPWR rf\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09871_ net969 _01843_ VGND VGND VPWR VPWR rf\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08966__980 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1092 sky130_fd_sc_hd__inv_2
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05965_ _02826_ VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__clkbuf_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07704_ rf\[28\]\[30\] rf\[29\]\[30\] rf\[30\]\[30\] rf\[31\]\[30\] _03590_ _03585_
+ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__mux4_2
X_04916_ rf\[6\]\[12\] _02090_ _02262_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__mux2_1
X_05896_ rf\[20\]\[21\] _02072_ _02780_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__mux2_1
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08247__300 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__inv_2
X_07635_ rf\[28\]\[26\] rf\[29\]\[26\] rf\[30\]\[26\] rf\[31\]\[26\] _03691_ _03626_
+ VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__mux4_2
XFILLER_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04847_ _02245_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__clkbuf_1
XFILLER_110_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07566_ _03629_ _04044_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__or2_1
X_04778_ rf\[4\]\[13\] _02088_ _02190_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__mux2_1
XFILLER_41_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09305_ net403 _01277_ VGND VGND VPWR VPWR rf\[16\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_06517_ _03111_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__clkbuf_1
X_07497_ rf\[8\]\[19\] rf\[9\]\[19\] rf\[10\]\[19\] rf\[11\]\[19\] _03662_ _03605_
+ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__mux4_1
X_09236_ net334 _01208_ VGND VGND VPWR VPWR rf\[14\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_06448_ rf\[12\]\[10\] _02094_ _03054_ VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__mux2_1
X_09167_ net265 _01139_ VGND VGND VPWR VPWR rf\[12\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_06379_ _02092_ rf\[13\]\[11\] _03019_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__mux2_1
XFILLER_119_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09098_ net196 _01070_ VGND VGND VPWR VPWR rf\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08049_ clknet_1_0__leaf__04446_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__buf_1
X_10011_ net1109 _01983_ VGND VGND VPWR VPWR rf\[19\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08835__855 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__inv_2
X_08040__104 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__inv_2
X_08155__213 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__inv_2
XFILLER_39_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05750_ _02715_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__clkbuf_1
X_05681_ _02056_ rf\[23\]\[29\] _02677_ VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__mux2_1
X_04701_ _02168_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__clkbuf_1
X_07420_ _03699_ _03906_ _03682_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__o21a_1
XFILLER_90_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04632_ _02132_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__clkbuf_1
XFILLER_35_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07351_ rf\[20\]\[12\] rf\[21\]\[12\] rf\[22\]\[12\] rf\[23\]\[12\] _03582_ _03626_
+ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__mux4_2
X_04563_ _02089_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08695__723 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__inv_2
XFILLER_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06302_ _03000_ VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__clkbuf_1
X_07282_ _03595_ _03769_ _03771_ _03773_ _03775_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__a32o_2
XFILLER_31_594 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06233_ _02078_ rf\[15\]\[18\] _02951_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__mux2_1
X_06164_ rf\[16\]\[19\] _02076_ _02916_ VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__mux2_1
X_05115_ rf\[8\]\[12\] _02090_ _02365_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__mux2_1
X_06095_ _02893_ VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__clkbuf_1
X_08318__367 clknet_1_1__leaf__04463_ VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__inv_2
X_09923_ net1021 _01895_ VGND VGND VPWR VPWR rf\[6\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_05046_ _02349_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__clkbuf_1
XFILLER_100_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09854_ net952 _01826_ VGND VGND VPWR VPWR rf\[7\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06997_ _03497_ _03499_ _03501_ _03503_ _03231_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__a221o_1
X_09785_ net883 _01757_ VGND VGND VPWR VPWR rf\[9\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_05948_ rf\[1\]\[28\] _02058_ _02814_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__mux2_1
X_05879_ _02782_ VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__clkbuf_1
XTAP_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07618_ _04088_ _04090_ _04092_ _04094_ _03608_ VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__a221o_1
XFILLER_10_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08858__877 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__inv_2
X_07549_ _03625_ _04028_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__or2_1
X_08063__126 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__inv_2
X_09219_ net317 _01191_ VGND VGND VPWR VPWR rf\[13\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08178__235 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__inv_2
XFILLER_30_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08605__639 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__inv_2
XFILLER_44_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06920_ _03231_ _03421_ _03430_ _03258_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__o211a_1
X_06851_ rf\[8\]\[20\] rf\[9\]\[20\] rf\[10\]\[20\] rf\[11\]\[20\] _03212_ _03213_
+ VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__mux4_1
X_09570_ net668 _01542_ VGND VGND VPWR VPWR rf\[24\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_05802_ _02741_ VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__clkbuf_1
X_06782_ _03211_ _03299_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__or2_1
XFILLER_82_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05733_ _02108_ rf\[23\]\[3\] _02676_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__mux2_1
XFILLER_82_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_483 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05664_ rf\[24\]\[4\] _02106_ _02641_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__mux2_1
X_08086__148 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__inv_2
X_07403_ _03625_ _03890_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__or2_1
X_05595_ _02104_ rf\[25\]\[5\] _02606_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__mux2_1
X_04615_ rf\[3\]\[27\] _02060_ _02119_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__mux2_1
XFILLER_50_166 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04546_ net20 VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__buf_12
X_08890__908 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1020 sky130_fd_sc_hd__inv_2
X_07334_ _03598_ _03824_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__or2_1
X_07265_ _03629_ _03759_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__or2_1
X_06216_ _02956_ VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__clkbuf_1
X_07196_ _03579_ _03692_ _03693_ VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__o21a_1
X_06147_ _02920_ VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__clkbuf_1
X_06078_ rf\[17\]\[29\] _02056_ _02882_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__mux2_1
XFILLER_4_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09906_ net1004 _01878_ VGND VGND VPWR VPWR rf\[6\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_05029_ rf\[7\]\[22\] _02070_ _02331_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__mux2_1
XFILLER_116_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09837_ net935 _01809_ VGND VGND VPWR VPWR rf\[8\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_09768_ net866 _01740_ VGND VGND VPWR VPWR rf\[30\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_74_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09699_ net797 _01671_ VGND VGND VPWR VPWR rf\[28\]\[21\] sky130_fd_sc_hd__dfxtp_1
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08650__681 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__inv_2
XFILLER_123_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08765__790 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__inv_2
XFILLER_64_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05380_ _02522_ VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__clkbuf_1
X_08046__110 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__inv_2
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07050_ _03247_ _03553_ _03273_ VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__o21a_1
XFILLER_9_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06001_ _02844_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__clkbuf_1
XFILLER_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput103 net103 VGND VGND VPWR VPWR port2_data_o[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_102_628 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07952_ rf\[24\]\[11\] rf\[25\]\[11\] rf\[26\]\[11\] rf\[27\]\[11\] _03198_ _03199_
+ VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__mux4_1
XFILLER_101_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04487_ clknet_0__04487_ VGND VGND VPWR VPWR clknet_1_1__leaf__04487_
+ sky130_fd_sc_hd__clkbuf_16
X_06903_ _03271_ _03413_ VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__or2_1
XFILLER_68_553 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07883_ _03211_ _04345_ _03265_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__o21a_1
X_09622_ net720 _01594_ VGND VGND VPWR VPWR rf\[26\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06834_ _03205_ _03346_ _03348_ _03216_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__a31o_1
X_09553_ net651 _01525_ VGND VGND VPWR VPWR rf\[24\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06765_ _03277_ _03279_ _03281_ _03283_ _03231_ VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__a221o_1
XFILLER_83_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09484_ net582 _01456_ VGND VGND VPWR VPWR rf\[21\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_05716_ _02697_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__clkbuf_1
X_06696_ _03205_ _03210_ _03215_ _03216_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__a31o_2
X_05647_ _02661_ VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05578_ _02625_ VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__clkbuf_1
X_07317_ rf\[12\]\[10\] rf\[13\]\[10\] rf\[14\]\[10\] rf\[15\]\[10\] _03599_ _03600_
+ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__mux4_1
X_04529_ _02066_ rf\[31\]\[24\] _02052_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__mux2_1
X_07248_ rf\[24\]\[6\] rf\[25\]\[6\] rf\[26\]\[6\] rf\[27\]\[6\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03744_ sky130_fd_sc_hd__mux4_2
X_07179_ _03595_ _03671_ _03673_ _03675_ _03677_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__a32o_1
XFILLER_3_516 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08634__665 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__inv_2
XFILLER_120_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_650 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput16 wr_data_i[14] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput27 wr_data_i[24] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_2
X_08494__533 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__inv_2
Xinput38 wr_data_i[5] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_108_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_626 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08018__83 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__inv_2
XFILLER_42_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08033__97 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__inv_2
XFILLER_38_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08117__177 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__inv_2
XFILLER_92_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04880_ rf\[6\]\[30\] _02054_ _02262_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__mux2_1
XFILLER_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08921__937 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1049 sky130_fd_sc_hd__inv_2
X_06550_ _02064_ rf\[29\]\[25\] _03122_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__mux2_1
X_05501_ _02585_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__clkbuf_1
X_06481_ _03093_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05432_ _02074_ rf\[27\]\[20\] _02538_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__mux2_1
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09049__52 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__inv_2
X_05363_ _02072_ rf\[28\]\[21\] _02503_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__mux2_1
XFILLER_119_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08657__687 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__inv_2
X_05294_ rf\[2\]\[22\] _02070_ _02468_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__mux2_1
X_07102_ _03581_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__buf_12
X_07033_ rf\[28\]\[29\] rf\[29\]\[29\] rf\[30\]\[29\] rf\[31\]\[29\] _03262_ _03263_
+ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__mux4_1
XFILLER_88_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07935_ rf\[8\]\[10\] rf\[9\]\[10\] rf\[10\]\[10\] rf\[11\]\[10\] _03212_ _03221_
+ VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__mux4_1
XFILLER_96_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08781__805 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__inv_2
XFILLER_28_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09605_ net703 _01577_ VGND VGND VPWR VPWR rf\[25\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_07866_ _03242_ _04329_ VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__or2_1
XFILLER_113_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06817_ rf\[20\]\[18\] rf\[21\]\[18\] rf\[22\]\[18\] rf\[23\]\[18\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__mux4_1
X_07797_ _03188_ _04261_ _04263_ _03203_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__o211a_1
XFILLER_43_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09536_ net634 _01508_ VGND VGND VPWR VPWR rf\[23\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06748_ _03189_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__buf_12
X_09467_ net565 _01439_ VGND VGND VPWR VPWR rf\[21\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06679_ rf\[4\]\[13\] rf\[5\]\[13\] rf\[6\]\[13\] rf\[7\]\[13\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03200_ sky130_fd_sc_hd__mux4_2
X_08404__449 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__inv_2
XFILLER_8_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09398_ net496 _01370_ VGND VGND VPWR VPWR rf\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08944__959 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1071 sky130_fd_sc_hd__inv_2
XFILLER_62_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05981_ _02834_ VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__clkbuf_1
XTAP_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07720_ _03629_ _04190_ VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__or2_1
XFILLER_78_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04932_ rf\[6\]\[4\] _02106_ _02261_ VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__mux2_1
X_07651_ rf\[20\]\[27\] rf\[21\]\[27\] rf\[22\]\[27\] rf\[23\]\[27\] _03662_ _03605_
+ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__mux4_2
XFILLER_93_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04863_ _02253_ VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__clkbuf_1
X_06602_ rf\[0\]\[31\] VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__clkbuf_1
X_07582_ rf\[0\]\[24\] rf\[1\]\[24\] rf\[2\]\[24\] rf\[3\]\[24\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _04060_ sky130_fd_sc_hd__mux4_1
X_09321_ net419 _01293_ VGND VGND VPWR VPWR rf\[16\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04794_ rf\[4\]\[5\] _02104_ _02189_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__mux2_1
X_06533_ _03119_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__clkbuf_1
X_06464_ rf\[12\]\[2\] _02110_ _03053_ VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__mux2_1
X_09252_ net350 _01224_ VGND VGND VPWR VPWR rf\[14\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_05415_ _02541_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__clkbuf_1
X_09183_ net281 _01155_ VGND VGND VPWR VPWR rf\[12\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06395_ _02108_ rf\[13\]\[3\] _03018_ VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__mux2_1
X_05346_ _02505_ VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05277_ _02469_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__clkbuf_1
X_07016_ _03515_ _03517_ _03519_ _03521_ _03216_ VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__a221o_1
XFILLER_88_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07918_ _03205_ _04376_ _04378_ _03216_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__a31o_1
X_07849_ _04307_ _04309_ _04311_ _04313_ _03230_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__a221o_1
XFILLER_17_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08904__921 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1033 sky130_fd_sc_hd__inv_2
XFILLER_44_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09519_ net617 _01491_ VGND VGND VPWR VPWR rf\[23\]\[1\] sky130_fd_sc_hd__dfxtp_1
XPHY_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09059__7 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__inv_2
X_10087_ net123 _01035_ VGND VGND VPWR VPWR rf\[31\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_610 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05200_ _02428_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__clkbuf_1
X_06180_ rf\[16\]\[11\] _02092_ _02916_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__mux2_1
X_05131_ rf\[8\]\[4\] _02106_ _02364_ VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__mux2_1
X_05062_ _02357_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__clkbuf_1
X_09870_ net968 _01842_ VGND VGND VPWR VPWR rf\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08433__475 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__inv_2
XFILLER_97_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08927__943 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1055 sky130_fd_sc_hd__inv_2
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05964_ rf\[1\]\[20\] _02074_ _02814_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__mux2_1
X_08752_ clknet_1_0__leaf__04479_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__buf_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07703_ _03580_ _04174_ VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__or2_1
X_04915_ _02281_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05895_ _02790_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__clkbuf_1
X_07634_ _03579_ _04109_ VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__or2_1
XFILLER_26_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04846_ rf\[5\]\[13\] _02088_ _02226_ VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__mux2_1
XFILLER_81_687 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07565_ rf\[16\]\[23\] rf\[17\]\[23\] rf\[18\]\[23\] rf\[19\]\[23\] _03639_ _03631_
+ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__mux4_1
X_04777_ _02208_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__clkbuf_1
XFILLER_13_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09304_ net402 _01276_ VGND VGND VPWR VPWR rf\[16\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_06516_ rf\[11\]\[9\] net42 _03088_ VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__mux2_1
X_07496_ _03625_ _03978_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__or2_1
X_06447_ _03075_ VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__clkbuf_1
X_09235_ net333 _01207_ VGND VGND VPWR VPWR rf\[14\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_09166_ net264 _01138_ VGND VGND VPWR VPWR rf\[12\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_06378_ _03039_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__clkbuf_1
XFILLER_107_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05329_ _02495_ VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__clkbuf_1
X_09097_ net195 _01069_ VGND VGND VPWR VPWR rf\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_08293__343 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__inv_2
X_08787__811 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__inv_2
X_10010_ net1108 _01982_ VGND VGND VPWR VPWR rf\[19\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09999_ net1097 _01971_ VGND VGND VPWR VPWR rf\[19\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08720__747 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__inv_2
XFILLER_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08456__497 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__inv_2
XFILLER_5_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04700_ rf\[19\]\[18\] _02078_ _02154_ VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__mux2_1
X_08580__615 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__inv_2
X_05680_ _02679_ VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__clkbuf_1
XFILLER_90_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04631_ rf\[3\]\[19\] _02076_ _02119_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__mux2_1
X_04562_ _02088_ rf\[31\]\[13\] _02052_ VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__mux2_1
XFILLER_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07350_ _03826_ _03831_ _03840_ _03650_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__o211a_1
X_06301_ _02080_ rf\[14\]\[17\] _02985_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__mux2_1
X_07281_ _03588_ _03774_ _03597_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__o21a_1
X_06232_ _02964_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__clkbuf_1
X_06163_ _02928_ VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__clkbuf_1
X_08203__259 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__inv_2
X_05114_ _02384_ VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06094_ rf\[17\]\[21\] _02072_ _02882_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__mux2_1
XFILLER_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09922_ net1020 _01894_ VGND VGND VPWR VPWR rf\[6\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_05045_ rf\[7\]\[14\] _02086_ _02331_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__mux2_1
XFILLER_86_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09853_ net951 _01825_ VGND VGND VPWR VPWR rf\[7\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_09784_ net882 _01756_ VGND VGND VPWR VPWR rf\[9\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06996_ _03196_ _03502_ _03265_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__o21a_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05947_ _02817_ VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__clkbuf_1
XFILLER_39_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05878_ rf\[20\]\[30\] _02054_ _02780_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__mux2_1
X_08743__769 clknet_1_1__leaf__04486_ VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__inv_2
XFILLER_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04829_ _02236_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__clkbuf_1
X_07617_ _03580_ _04093_ _03693_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__o21a_1
XFILLER_53_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07548_ rf\[12\]\[22\] rf\[13\]\[22\] rf\[14\]\[22\] rf\[15\]\[22\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__mux4_1
X_07479_ _03598_ _03962_ _03682_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__o21a_1
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09218_ net316 _01190_ VGND VGND VPWR VPWR rf\[13\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09149_ net247 _01121_ VGND VGND VPWR VPWR rf\[11\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08679__708 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__inv_2
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06850_ _03206_ _03363_ VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__or2_1
X_05801_ _02110_ rf\[22\]\[2\] _02710_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__mux2_1
XFILLER_83_705 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06781_ rf\[24\]\[16\] rf\[25\]\[16\] rf\[26\]\[16\] rf\[27\]\[16\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__mux4_1
XFILLER_27_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05732_ _02705_ VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__clkbuf_1
X_08451_ clknet_1_1__leaf__04468_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__buf_1
X_05663_ _02669_ VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__clkbuf_1
XFILLER_35_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_270 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04614_ _02123_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__clkbuf_1
X_08703__731 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__inv_2
X_07402_ rf\[12\]\[14\] rf\[13\]\[14\] rf\[14\]\[14\] rf\[15\]\[14\] _03630_ _03613_
+ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__mux4_1
XFILLER_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05594_ _02633_ VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04545_ _02077_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__clkbuf_1
X_07333_ rf\[4\]\[11\] rf\[5\]\[11\] rf\[6\]\[11\] rf\[7\]\[11\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03824_ sky130_fd_sc_hd__mux4_1
XFILLER_50_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07264_ rf\[16\]\[7\] rf\[17\]\[7\] rf\[18\]\[7\] rf\[19\]\[7\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03759_ sky130_fd_sc_hd__mux4_1
X_06215_ _02060_ rf\[15\]\[27\] _02951_ VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__mux2_1
XFILLER_3_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07195_ net9 VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__clkbuf_16
X_08439__481 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__inv_2
X_06146_ rf\[16\]\[28\] _02058_ _02916_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__mux2_1
X_06077_ _02884_ VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__clkbuf_1
X_09905_ net1003 _01877_ VGND VGND VPWR VPWR rf\[6\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_05028_ _02340_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__clkbuf_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09836_ net934 _01808_ VGND VGND VPWR VPWR rf\[8\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_06979_ _03486_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
X_09767_ net865 _01739_ VGND VGND VPWR VPWR rf\[30\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_73_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09698_ net796 _01670_ VGND VGND VPWR VPWR rf\[28\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_576 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_705 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08726__753 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__inv_2
X_08232__285 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__inv_2
XFILLER_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_690 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06000_ rf\[1\]\[2\] _02110_ _02813_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__mux2_1
Xoutput104 net104 VGND VGND VPWR VPWR port2_data_o[30] sky130_fd_sc_hd__clkbuf_4
X_07951_ _03242_ _04409_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__or2_1
X_06902_ rf\[20\]\[23\] rf\[21\]\[23\] rf\[22\]\[23\] rf\[23\]\[23\] _03190_ _03263_
+ VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04486_ clknet_0__04486_ VGND VGND VPWR VPWR clknet_1_1__leaf__04486_
+ sky130_fd_sc_hd__clkbuf_16
X_08586__621 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__inv_2
XFILLER_68_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08092__153 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__inv_2
X_07882_ rf\[8\]\[7\] rf\[9\]\[7\] rf\[10\]\[7\] rf\[11\]\[7\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _04345_ sky130_fd_sc_hd__mux4_1
X_09621_ net719 _01593_ VGND VGND VPWR VPWR rf\[26\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_06833_ _03211_ _03347_ VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__or2_1
X_09552_ net650 _01524_ VGND VGND VPWR VPWR rf\[24\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_06764_ _03271_ _03282_ _03265_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__o21a_1
XFILLER_83_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05715_ _02090_ rf\[23\]\[12\] _02677_ VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__mux2_1
X_09483_ net581 _01455_ VGND VGND VPWR VPWR rf\[21\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06695_ net5 VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__clkbuf_16
X_05646_ rf\[24\]\[13\] _02088_ _02642_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__mux2_1
XFILLER_23_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05577_ _02086_ rf\[25\]\[14\] _02607_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__mux2_1
X_04528_ net27 VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__buf_12
X_07316_ _03580_ _03805_ _03807_ _03595_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__o211a_1
X_07247_ _03699_ _03742_ _03682_ VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__o21a_1
X_07178_ _03588_ _03676_ _03597_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__o21a_1
XFILLER_3_528 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06129_ _02910_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__clkbuf_1
X_08749__775 clknet_1_1__leaf__04486_ VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__inv_2
XFILLER_101_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09819_ net917 _01791_ VGND VGND VPWR VPWR rf\[8\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_19_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput17 wr_data_i[15] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput28 wr_data_i[25] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_2
Xinput39 wr_data_i[6] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_123_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_638 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_708 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05500_ _02076_ rf\[26\]\[19\] _02572_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__mux2_1
XFILLER_61_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06480_ rf\[11\]\[27\] net30 _03088_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__mux2_1
X_08542__579 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__inv_2
X_05431_ _02549_ VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__clkbuf_1
X_05362_ _02513_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__clkbuf_1
X_07101_ _03578_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__buf_8
X_09064__12 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__inv_2
X_05293_ _02477_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__clkbuf_1
X_07032_ _03261_ _03536_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__or2_1
XFILLER_115_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04469_ clknet_0__04469_ VGND VGND VPWR VPWR clknet_1_1__leaf__04469_
+ sky130_fd_sc_hd__clkbuf_16
X_07934_ _03206_ _04393_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__or2_1
X_07865_ rf\[24\]\[6\] rf\[25\]\[6\] rf\[26\]\[6\] rf\[27\]\[6\] _03251_ _03244_ VGND
+ VGND VPWR VPWR _04329_ sky130_fd_sc_hd__mux4_1
XFILLER_29_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09604_ net702 _01576_ VGND VGND VPWR VPWR rf\[25\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06816_ _03187_ _03331_ VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__or2_1
XFILLER_83_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07796_ _03247_ _04262_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__or2_1
X_09535_ net633 _01507_ VGND VGND VPWR VPWR rf\[23\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06747_ _03261_ _03264_ _03265_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__o21a_1
X_09466_ net564 _01438_ VGND VGND VPWR VPWR rf\[21\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_06678_ _03192_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__buf_12
X_05629_ _02652_ VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__clkbuf_1
XFILLER_24_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09397_ net495 _01369_ VGND VGND VPWR VPWR rf\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_08478__518 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__inv_2
XFILLER_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_518 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04489_ clknet_0__04489_ VGND VGND VPWR VPWR clknet_1_0__leaf__04489_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_15_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08502__541 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__inv_2
XFILLER_8_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08238__291 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__inv_2
XFILLER_85_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05980_ rf\[1\]\[12\] _02090_ _02814_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__mux2_1
XTAP_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04931_ _02289_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__clkbuf_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07650_ _03579_ _04124_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__or2_1
X_04862_ rf\[5\]\[5\] _02104_ _02225_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__mux2_1
XFILLER_93_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07581_ _03623_ _04050_ _04059_ _03650_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__o211a_1
X_06601_ _03154_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__clkbuf_1
X_04793_ _02216_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09320_ net418 _01292_ VGND VGND VPWR VPWR rf\[16\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_06532_ rf\[11\]\[1\] net22 _03087_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__mux2_1
X_09251_ net349 _01223_ VGND VGND VPWR VPWR rf\[14\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_61_593 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06463_ _03083_ VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__clkbuf_1
X_05414_ _02056_ rf\[27\]\[29\] _02538_ VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__mux2_1
X_09182_ net280 _01154_ VGND VGND VPWR VPWR rf\[12\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_06394_ _03047_ VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__clkbuf_1
X_05345_ _02054_ rf\[28\]\[30\] _02503_ VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__mux2_1
XFILLER_107_518 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07015_ _03196_ _03520_ _03203_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__o21a_1
X_05276_ rf\[2\]\[31\] _02048_ _02468_ VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__mux2_1
XFILLER_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07917_ _03211_ _04377_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__or2_1
X_07848_ _03271_ _04312_ _03265_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__o21a_1
XFILLER_83_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09518_ net616 _01490_ VGND VGND VPWR VPWR rf\[23\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07779_ _03261_ _04246_ VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__or2_1
X_08525__563 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__inv_2
XPHY_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09449_ net547 _01421_ VGND VGND VPWR VPWR rf\[20\]\[27\] sky130_fd_sc_hd__dfxtp_1
XPHY_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_438 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10086_ net122 _01034_ VGND VGND VPWR VPWR rf\[31\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_08385__431 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__inv_2
XFILLER_90_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09019__23 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__inv_2
X_05130_ _02392_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__clkbuf_1
X_09034__37 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__inv_2
X_05061_ rf\[7\]\[6\] _02102_ _02331_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__mux2_1
XFILLER_97_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_598 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05963_ _02825_ VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__clkbuf_1
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05894_ rf\[20\]\[22\] _02070_ _02780_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__mux2_1
X_07702_ rf\[24\]\[30\] rf\[25\]\[30\] rf\[26\]\[30\] rf\[27\]\[30\] _03590_ _03591_
+ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__mux4_1
X_04914_ rf\[6\]\[13\] _02088_ _02262_ VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__mux2_1
X_08548__585 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__inv_2
X_07633_ rf\[24\]\[26\] rf\[25\]\[26\] rf\[26\]\[26\] rf\[27\]\[26\] _03695_ _03696_
+ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__mux4_1
XFILLER_81_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04845_ _02244_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07564_ _03699_ _04042_ VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__or2_1
XFILLER_81_699 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04776_ rf\[4\]\[14\] _02086_ _02190_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09303_ net401 _01275_ VGND VGND VPWR VPWR rf\[16\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_06515_ _03110_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__clkbuf_1
X_07495_ rf\[12\]\[19\] rf\[13\]\[19\] rf\[14\]\[19\] rf\[15\]\[19\] _03639_ _03631_
+ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__mux4_1
XFILLER_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06446_ rf\[12\]\[11\] _02092_ _03054_ VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__mux2_1
X_09234_ net332 _01206_ VGND VGND VPWR VPWR rf\[14\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_09165_ net263 _01137_ VGND VGND VPWR VPWR rf\[11\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06377_ _02090_ rf\[13\]\[12\] _03019_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__mux2_1
XFILLER_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05328_ rf\[2\]\[5\] _02104_ _02467_ VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__mux2_1
X_09096_ net194 _01068_ VGND VGND VPWR VPWR rf\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05259_ _02459_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__clkbuf_1
X_08254__306 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__inv_2
XFILLER_0_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09998_ net1096 _01970_ VGND VGND VPWR VPWR rf\[19\]\[0\] sky130_fd_sc_hd__dfxtp_2
XFILLER_69_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_516 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08341__389 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__inv_2
X_09061__9 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__inv_2
XFILLER_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10069_ net160 _02041_ VGND VGND VPWR VPWR rf\[31\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08881__899 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1011 sky130_fd_sc_hd__inv_2
XFILLER_48_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04630_ _02131_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_90_496 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04561_ net15 VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__buf_12
XFILLER_50_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07280_ rf\[28\]\[8\] rf\[29\]\[8\] rf\[30\]\[8\] rf\[31\]\[8\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03774_ sky130_fd_sc_hd__mux4_1
X_06300_ _02999_ VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__clkbuf_1
XFILLER_43_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06231_ _02076_ rf\[15\]\[19\] _02951_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__mux2_1
X_06162_ rf\[16\]\[20\] _02074_ _02916_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__mux2_1
X_08277__328 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__inv_2
X_06093_ _02892_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__clkbuf_1
X_05113_ rf\[8\]\[13\] _02088_ _02365_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__mux2_1
XFILLER_116_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09921_ net1019 _01893_ VGND VGND VPWR VPWR rf\[6\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_05044_ _02348_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09852_ net950 _01824_ VGND VGND VPWR VPWR rf\[7\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_85_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09783_ net881 _01755_ VGND VGND VPWR VPWR rf\[9\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06995_ rf\[28\]\[27\] rf\[29\]\[27\] rf\[30\]\[27\] rf\[31\]\[27\] _03254_ _03208_
+ VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__mux4_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05946_ rf\[1\]\[29\] _02056_ _02814_ VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__mux2_1
XFILLER_39_696 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05877_ _02781_ VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07616_ rf\[8\]\[25\] rf\[9\]\[25\] rf\[10\]\[25\] rf\[11\]\[25\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__mux4_2
XFILLER_41_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04828_ rf\[5\]\[22\] _02070_ _02226_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__mux2_1
X_07547_ _03580_ _04024_ _04026_ _03595_ VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__o211a_1
XFILLER_54_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04759_ _02199_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__clkbuf_1
X_07478_ rf\[20\]\[18\] rf\[21\]\[18\] rf\[22\]\[18\] rf\[23\]\[18\] _03662_ _03605_
+ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__mux4_1
XFILLER_14_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09217_ net315 _01189_ VGND VGND VPWR VPWR rf\[13\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_06429_ _03066_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__clkbuf_1
X_09148_ net246 _01120_ VGND VGND VPWR VPWR rf\[11\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_30_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08301__351 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__inv_2
X_09079_ net177 _01051_ VGND VGND VPWR VPWR rf\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_89_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08841__861 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__inv_2
XFILLER_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08956__970 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1082 sky130_fd_sc_hd__inv_2
XFILLER_65_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05800_ _02740_ VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__clkbuf_1
X_06780_ _03247_ _03297_ _03203_ VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__o21a_1
XFILLER_83_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05731_ _02106_ rf\[23\]\[4\] _02676_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__mux2_1
X_05662_ rf\[24\]\[5\] _02104_ _02641_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__mux2_1
XFILLER_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04613_ rf\[3\]\[28\] _02058_ _02119_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__mux2_1
XFILLER_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07401_ _03603_ _03888_ _03682_ VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__o21a_1
X_05593_ _02102_ rf\[25\]\[6\] _02607_ VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__mux2_1
X_07332_ rf\[0\]\[11\] rf\[1\]\[11\] rf\[2\]\[11\] rf\[3\]\[11\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03823_ sky130_fd_sc_hd__mux4_1
XFILLER_51_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04544_ _02076_ rf\[31\]\[19\] _02052_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__mux2_1
X_08324__373 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__inv_2
X_07263_ _03597_ _03755_ _03757_ _03608_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__a31o_1
XFILLER_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06214_ _02955_ VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__clkbuf_1
X_07194_ rf\[8\]\[4\] rf\[9\]\[4\] rf\[10\]\[4\] rf\[11\]\[4\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _03692_ sky130_fd_sc_hd__mux4_1
X_06145_ _02919_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06076_ rf\[17\]\[30\] _02054_ _02882_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__mux2_1
XFILLER_59_703 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09904_ net1002 _01876_ VGND VGND VPWR VPWR rf\[6\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_05027_ rf\[7\]\[23\] _02068_ _02331_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__mux2_1
XFILLER_113_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09835_ net933 _01807_ VGND VGND VPWR VPWR rf\[8\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06978_ _03220_ _03476_ _03485_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__and3_4
X_09766_ net864 _01738_ VGND VGND VPWR VPWR rf\[30\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_08864__883 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__inv_2
X_05929_ _02807_ VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__clkbuf_1
X_09697_ net795 _01669_ VGND VGND VPWR VPWR rf\[28\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08979__992 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1104 sky130_fd_sc_hd__inv_2
XFILLER_54_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08184__241 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__inv_2
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08347__395 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__inv_2
XFILLER_13_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput105 net105 VGND VGND VPWR VPWR port2_data_o[31] sky130_fd_sc_hd__buf_2
XFILLER_99_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07950_ rf\[16\]\[11\] rf\[17\]\[11\] rf\[18\]\[11\] rf\[19\]\[11\] _03243_ _03244_
+ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04485_ clknet_0__04485_ VGND VGND VPWR VPWR clknet_1_1__leaf__04485_
+ sky130_fd_sc_hd__clkbuf_16
X_06901_ _03398_ _03403_ _03412_ _03258_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__o211a_1
XFILLER_110_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08053__116 clknet_1_1__leaf__04449_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__inv_2
X_07881_ _03206_ _04343_ VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__or2_1
X_09620_ net718 _01592_ VGND VGND VPWR VPWR rf\[26\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06832_ rf\[8\]\[19\] rf\[9\]\[19\] rf\[10\]\[19\] rf\[11\]\[19\] _03212_ _03213_
+ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__mux4_1
X_09551_ net649 _01523_ VGND VGND VPWR VPWR rf\[24\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06763_ rf\[28\]\[15\] rf\[29\]\[15\] rf\[30\]\[15\] rf\[31\]\[15\] _03262_ _03263_
+ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__mux4_1
X_05714_ _02696_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__clkbuf_1
XFILLER_70_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09482_ net580 _01454_ VGND VGND VPWR VPWR rf\[21\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06694_ _03211_ _03214_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__or2_1
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05645_ _02660_ VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__clkbuf_1
X_05576_ _02624_ VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__clkbuf_1
X_04527_ _02065_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__clkbuf_1
X_07315_ _03598_ _03806_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__or2_1
X_07246_ rf\[20\]\[6\] rf\[21\]\[6\] rf\[22\]\[6\] rf\[23\]\[6\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03742_ sky130_fd_sc_hd__mux4_2
X_07177_ rf\[28\]\[3\] rf\[29\]\[3\] rf\[30\]\[3\] rf\[31\]\[3\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03676_ sky130_fd_sc_hd__mux4_1
XFILLER_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06128_ rf\[17\]\[4\] _02106_ _02881_ VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__mux2_1
X_08140__199 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__inv_2
X_06059_ _02874_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__clkbuf_1
XFILLER_101_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_566 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09818_ net916 _01790_ VGND VGND VPWR VPWR rf\[8\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_09749_ net847 _01721_ VGND VGND VPWR VPWR rf\[30\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput18 wr_data_i[16] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_109_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput29 wr_data_i[26] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XFILLER_117_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08076__138 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__inv_2
XFILLER_123_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05430_ _02072_ rf\[27\]\[21\] _02538_ VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__mux2_1
XTAP_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05361_ _02070_ rf\[28\]\[22\] _02503_ VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__mux2_1
XFILLER_119_527 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07100_ _03598_ _03601_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__or2_1
X_05292_ rf\[2\]\[23\] _02068_ _02468_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__mux2_1
X_07031_ rf\[24\]\[29\] rf\[25\]\[29\] rf\[26\]\[29\] rf\[27\]\[29\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__mux4_1
X_08100__161 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04468_ clknet_0__04468_ VGND VGND VPWR VPWR clknet_1_1__leaf__04468_
+ sky130_fd_sc_hd__clkbuf_16
X_07933_ rf\[12\]\[10\] rf\[13\]\[10\] rf\[14\]\[10\] rf\[15\]\[10\] _03248_ _03208_
+ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__mux4_1
X_07864_ _03247_ _04327_ _03273_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__o21a_1
Xclkbuf_0__04499_ _04499_ VGND VGND VPWR VPWR clknet_0__04499_ sky130_fd_sc_hd__clkbuf_16
XFILLER_113_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09603_ net701 _01575_ VGND VGND VPWR VPWR rf\[25\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_06815_ rf\[16\]\[18\] rf\[17\]\[18\] rf\[18\]\[18\] rf\[19\]\[18\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__mux4_1
XFILLER_83_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07795_ rf\[4\]\[3\] rf\[5\]\[3\] rf\[6\]\[3\] rf\[7\]\[3\] _03254_ _03199_ VGND
+ VGND VPWR VPWR _04262_ sky130_fd_sc_hd__mux4_1
XFILLER_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09534_ net632 _01506_ VGND VGND VPWR VPWR rf\[23\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06746_ net4 VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__clkbuf_16
X_09465_ net563 _01437_ VGND VGND VPWR VPWR rf\[21\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_06677_ _03197_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__buf_12
X_05628_ rf\[24\]\[22\] _02070_ _02642_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__mux2_1
XFILLER_12_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08640__671 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__inv_2
X_09396_ net494 _01368_ VGND VGND VPWR VPWR rf\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_05559_ _02068_ rf\[25\]\[23\] _02607_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__mux2_1
X_07229_ rf\[24\]\[5\] rf\[25\]\[5\] rf\[26\]\[5\] rf\[27\]\[5\] _03604_ _03613_ VGND
+ VGND VPWR VPWR _03726_ sky130_fd_sc_hd__mux4_2
X_08755__780 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__inv_2
XFILLER_105_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08036__100 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__inv_2
XFILLER_74_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_396 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_74 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04488_ clknet_0__04488_ VGND VGND VPWR VPWR clknet_1_0__leaf__04488_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08123__183 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__inv_2
XFILLER_124_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04930_ rf\[6\]\[5\] _02104_ _02261_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__mux2_1
XFILLER_77_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_322 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_366 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04861_ _02252_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__clkbuf_1
XFILLER_93_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04792_ rf\[4\]\[6\] _02102_ _02190_ VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__mux2_1
X_07580_ _04052_ _04054_ _04056_ _04058_ _03608_ VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__a221o_1
X_06600_ _02114_ rf\[29\]\[0\] _03121_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__mux2_1
X_08663__693 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__inv_2
X_06531_ _03118_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__clkbuf_1
XFILLER_18_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09250_ net348 _01222_ VGND VGND VPWR VPWR rf\[14\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_06462_ rf\[12\]\[3\] _02108_ _03053_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__mux2_1
X_05413_ _02540_ VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__clkbuf_1
X_09181_ net279 _01153_ VGND VGND VPWR VPWR rf\[12\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_06393_ _02106_ rf\[13\]\[4\] _03018_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__mux2_1
XFILLER_119_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05344_ _02504_ VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__clkbuf_1
X_05275_ _02467_ VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__buf_12
X_07014_ rf\[4\]\[28\] rf\[5\]\[28\] rf\[6\]\[28\] rf\[7\]\[28\] _03254_ _03208_ VGND
+ VGND VPWR VPWR _03520_ sky130_fd_sc_hd__mux4_1
X_08059__122 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__inv_2
XFILLER_102_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07916_ rf\[8\]\[9\] rf\[9\]\[9\] rf\[10\]\[9\] rf\[11\]\[9\] _03212_ _03221_ VGND
+ VGND VPWR VPWR _04377_ sky130_fd_sc_hd__mux4_1
X_07847_ rf\[28\]\[5\] rf\[29\]\[5\] rf\[30\]\[5\] rf\[31\]\[5\] _03262_ _03263_ VGND
+ VGND VPWR VPWR _04312_ sky130_fd_sc_hd__mux4_1
XFILLER_17_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07778_ rf\[0\]\[2\] rf\[1\]\[2\] rf\[2\]\[2\] rf\[3\]\[2\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04246_ sky130_fd_sc_hd__mux4_1
X_09517_ net615 _01489_ VGND VGND VPWR VPWR rf\[22\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_06729_ rf\[20\]\[14\] rf\[21\]\[14\] rf\[22\]\[14\] rf\[23\]\[14\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__mux4_1
XFILLER_83_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09448_ net546 _01420_ VGND VGND VPWR VPWR rf\[20\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_09379_ net477 _01351_ VGND VGND VPWR VPWR rf\[18\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08950__965 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1077 sky130_fd_sc_hd__inv_2
XFILLER_4_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10085_ net121 _01033_ VGND VGND VPWR VPWR rf\[31\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08886__904 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1016 sky130_fd_sc_hd__inv_2
X_05060_ _02356_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__clkbuf_1
XFILLER_112_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05962_ rf\[1\]\[21\] _02072_ _02814_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__mux2_1
X_05893_ _02789_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07701_ _03629_ _04172_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__or2_1
X_04913_ _02280_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__clkbuf_1
X_07632_ _03699_ _04107_ _03594_ VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__o21a_1
X_04844_ rf\[5\]\[14\] _02086_ _02226_ VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__mux2_1
XFILLER_26_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08509__548 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__inv_2
XFILLER_53_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07563_ rf\[20\]\[23\] rf\[21\]\[23\] rf\[22\]\[23\] rf\[23\]\[23\] _03582_ _03626_
+ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__mux4_2
X_09302_ net400 _01274_ VGND VGND VPWR VPWR rf\[16\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_04775_ _02207_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__clkbuf_1
XFILLER_22_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07494_ _03595_ _03970_ _03972_ _03974_ _03976_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__a32o_1
X_06514_ rf\[11\]\[10\] net12 _03088_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__mux2_1
XFILLER_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06445_ _03074_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__clkbuf_1
X_09233_ net331 _01205_ VGND VGND VPWR VPWR rf\[14\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_08934__949 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1061 sky130_fd_sc_hd__inv_2
X_09164_ net262 _01136_ VGND VGND VPWR VPWR rf\[11\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_06376_ _03038_ VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05327_ _02494_ VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__clkbuf_1
X_09095_ net193 _01067_ VGND VGND VPWR VPWR rf\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_05258_ _02100_ rf\[30\]\[7\] _02434_ VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__mux2_1
XFILLER_103_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05189_ rf\[9\]\[8\] _02098_ _02399_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__mux2_1
XFILLER_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09997_ net1095 _01969_ VGND VGND VPWR VPWR rf\[4\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08369__416 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__inv_2
XFILLER_56_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08794__817 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__inv_2
XFILLER_9_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10068_ net159 _02040_ VGND VGND VPWR VPWR rf\[31\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04560_ _02087_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06230_ _02963_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__clkbuf_1
X_06161_ _02927_ VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__clkbuf_1
X_06092_ rf\[17\]\[22\] _02070_ _02882_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__mux2_1
X_05112_ _02383_ VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09920_ net1018 _01892_ VGND VGND VPWR VPWR rf\[6\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_05043_ rf\[7\]\[15\] _02084_ _02331_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__mux2_1
X_08554__590 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__inv_2
XFILLER_112_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_575 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09851_ net949 _01823_ VGND VGND VPWR VPWR rf\[7\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06994_ _03242_ _03500_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__or2_2
XFILLER_86_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09782_ net880 _01754_ VGND VGND VPWR VPWR rf\[9\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05945_ _02816_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__clkbuf_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05876_ rf\[20\]\[31\] _02048_ _02780_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__mux2_1
XFILLER_54_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04827_ _02235_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__clkbuf_1
X_07615_ _03625_ _04091_ VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__or2_1
X_04758_ rf\[4\]\[23\] _02068_ _02190_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__mux2_1
X_07546_ _03598_ _04025_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__or2_1
X_07477_ _03579_ _03960_ VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__or2_1
X_04689_ _02162_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__clkbuf_1
X_09216_ net314 _01188_ VGND VGND VPWR VPWR rf\[13\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06428_ rf\[12\]\[20\] _02074_ _03054_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__mux2_1
X_09147_ net245 _01119_ VGND VGND VPWR VPWR rf\[11\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_06359_ _02072_ rf\[13\]\[21\] _03019_ VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__mux2_1
XFILLER_108_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09078_ net176 _01050_ VGND VGND VPWR VPWR rf\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08029_ clknet_1_1__leaf__04446_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__buf_1
XFILLER_49_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08917__933 clknet_1_0__leaf__04496_ VGND VGND VPWR VPWR net1045 sky130_fd_sc_hd__inv_2
XFILLER_9_568 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_704 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05730_ _02704_ VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05661_ _02668_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__clkbuf_1
XFILLER_90_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07400_ rf\[0\]\[14\] rf\[1\]\[14\] rf\[2\]\[14\] rf\[3\]\[14\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _03888_ sky130_fd_sc_hd__mux4_2
X_04612_ _02122_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__clkbuf_1
X_08777__801 clknet_1_1__leaf__04488_ VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__inv_2
X_05592_ _02632_ VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__clkbuf_1
X_07331_ _03808_ _03813_ _03822_ _03650_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__o211a_1
X_04543_ net21 VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__buf_12
X_07262_ _03603_ _03756_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__or2_1
X_07193_ _03581_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__buf_12
X_06213_ _02058_ rf\[15\]\[28\] _02951_ VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__mux2_1
XFILLER_117_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06144_ rf\[16\]\[29\] _02056_ _02916_ VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__mux2_1
XFILLER_105_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06075_ _02883_ VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05026_ _02339_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__clkbuf_1
X_09903_ net1001 _01875_ VGND VGND VPWR VPWR rf\[6\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_59_715 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09834_ net932 _01806_ VGND VGND VPWR VPWR rf\[8\]\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06977_ _03478_ _03480_ _03482_ _03484_ _03231_ VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__a221o_1
X_09765_ net863 _01737_ VGND VGND VPWR VPWR rf\[30\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_08825__846 clknet_1_1__leaf__04491_ VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__inv_2
X_05928_ rf\[20\]\[5\] _02104_ _02779_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__mux2_1
X_09696_ net794 _01668_ VGND VGND VPWR VPWR rf\[28\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05859_ _02102_ rf\[21\]\[6\] _02745_ VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__mux2_1
XTAP_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_497 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08145__204 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__inv_2
X_07529_ rf\[12\]\[21\] rf\[13\]\[21\] rf\[14\]\[21\] rf\[15\]\[21\] _03599_ _03600_
+ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__mux4_1
XFILLER_108_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08685__714 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__inv_2
XFILLER_1_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08308__358 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__inv_2
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08733__759 clknet_1_1__leaf__04486_ VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__inv_2
Xoutput106 net106 VGND VGND VPWR VPWR port2_data_o[3] sky130_fd_sc_hd__buf_2
XFILLER_114_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06900_ _03405_ _03407_ _03409_ _03411_ _03231_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__a221o_1
Xclkbuf_1_1__f__04484_ clknet_0__04484_ VGND VGND VPWR VPWR clknet_1_1__leaf__04484_
+ sky130_fd_sc_hd__clkbuf_16
X_08848__868 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__inv_2
X_07880_ rf\[12\]\[7\] rf\[13\]\[7\] rf\[14\]\[7\] rf\[15\]\[7\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _04343_ sky130_fd_sc_hd__mux4_2
XFILLER_68_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06831_ _03206_ _03345_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__or2_1
X_09550_ net648 _01522_ VGND VGND VPWR VPWR rf\[24\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_06762_ _03261_ _03280_ VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__or2_1
X_09481_ net579 _01453_ VGND VGND VPWR VPWR rf\[21\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_05713_ _02088_ rf\[23\]\[13\] _02677_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__mux2_1
XFILLER_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06693_ rf\[8\]\[13\] rf\[9\]\[13\] rf\[10\]\[13\] rf\[11\]\[13\] _03212_ _03213_
+ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__mux4_1
X_08168__226 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__inv_2
X_05644_ rf\[24\]\[14\] _02086_ _02642_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__mux2_1
XFILLER_51_423 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05575_ _02084_ rf\[25\]\[15\] _02607_ VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__mux2_1
XFILLER_23_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04526_ _02064_ rf\[31\]\[25\] _02052_ VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__mux2_1
X_07314_ rf\[4\]\[10\] rf\[5\]\[10\] rf\[6\]\[10\] rf\[7\]\[10\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03806_ sky130_fd_sc_hd__mux4_1
XFILLER_32_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08593__627 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__inv_2
X_07245_ _03578_ _03740_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__or2_1
XFILLER_11_14 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07176_ _03580_ _03674_ VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__or2_1
XFILLER_117_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06127_ _02909_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__clkbuf_1
XFILLER_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06058_ rf\[18\]\[6\] _02102_ _02848_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__mux2_1
X_05009_ _02116_ _02187_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__nor2_4
XFILLER_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_578 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09817_ net915 _01789_ VGND VGND VPWR VPWR rf\[8\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09748_ net846 _01720_ VGND VGND VPWR VPWR rf\[30\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09679_ net777 _01651_ VGND VGND VPWR VPWR rf\[28\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 wr_data_i[17] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_124_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05360_ _02512_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__clkbuf_1
XFILLER_14_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_539 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05291_ _02476_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__clkbuf_1
X_07030_ _03271_ _03534_ _03202_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__o21a_1
XFILLER_87_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f__04467_ clknet_0__04467_ VGND VGND VPWR VPWR clknet_1_1__leaf__04467_
+ sky130_fd_sc_hd__clkbuf_16
X_07932_ _03188_ _04389_ _04391_ _03203_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__o211a_2
X_08024__89 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__inv_2
XFILLER_110_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07863_ rf\[20\]\[6\] rf\[21\]\[6\] rf\[22\]\[6\] rf\[23\]\[6\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _04327_ sky130_fd_sc_hd__mux4_1
XFILLER_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_0__04498_ _04498_ VGND VGND VPWR VPWR clknet_0__04498_ sky130_fd_sc_hd__clkbuf_16
X_09602_ net700 _01574_ VGND VGND VPWR VPWR rf\[25\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_68_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06814_ _03323_ _03325_ _03327_ _03329_ _03216_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__a221o_2
X_09533_ net631 _01505_ VGND VGND VPWR VPWR rf\[23\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07794_ rf\[0\]\[3\] rf\[1\]\[3\] rf\[2\]\[3\] rf\[3\]\[3\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04261_ sky130_fd_sc_hd__mux4_1
XFILLER_56_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06745_ rf\[8\]\[15\] rf\[9\]\[15\] rf\[10\]\[15\] rf\[11\]\[15\] _03262_ _03263_
+ VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__mux4_2
X_06676_ _03189_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__buf_12
X_09464_ net562 _01436_ VGND VGND VPWR VPWR rf\[21\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05627_ _02651_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__clkbuf_1
X_09395_ net493 _01367_ VGND VGND VPWR VPWR rf\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_05558_ _02615_ VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05489_ _02579_ VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__clkbuf_1
X_04509_ _02053_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_106_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08716__743 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__inv_2
X_07228_ _03598_ _03724_ _03682_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__o21a_1
X_07159_ _03597_ _03656_ _03658_ _03608_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__a31o_1
XFILLER_120_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08461__502 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__inv_2
XTAP_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_86 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04487_ clknet_0__04487_ VGND VGND VPWR VPWR clknet_1_0__leaf__04487_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_30_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08576__611 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__inv_2
XFILLER_11_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04860_ rf\[5\]\[6\] _02102_ _02226_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__mux2_1
XFILLER_92_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04791_ _02215_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__clkbuf_1
X_08624__656 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__inv_2
XFILLER_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06530_ rf\[11\]\[2\] net33 _03087_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__mux2_1
X_06461_ _03082_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__clkbuf_1
XFILLER_33_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05412_ _02054_ rf\[27\]\[30\] _02538_ VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__mux2_1
XFILLER_33_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09180_ net278 _01152_ VGND VGND VPWR VPWR rf\[12\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_06392_ _03046_ VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__clkbuf_1
X_05343_ _02048_ rf\[28\]\[31\] _02503_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__mux2_1
X_08739__765 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__inv_2
X_05274_ _02117_ _02260_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__nor2_4
X_07013_ _03242_ _03518_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__or2_1
XFILLER_0_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07915_ _03206_ _04375_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__or2_1
XFILLER_69_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08484__524 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__inv_2
X_07846_ _03261_ _04310_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__or2_1
XFILLER_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04989_ rf\[10\]\[9\] _02096_ _02297_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__mux2_1
X_07777_ _03261_ _04244_ net4 VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__o21a_1
X_09516_ net614 _01488_ VGND VGND VPWR VPWR rf\[22\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_06728_ _03189_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__buf_12
XFILLER_83_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09447_ net545 _01419_ VGND VGND VPWR VPWR rf\[20\]\[25\] sky130_fd_sc_hd__dfxtp_1
XPHY_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08599__633 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__inv_2
X_06659_ _03183_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09378_ net476 _01350_ VGND VGND VPWR VPWR rf\[18\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08107__168 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__inv_2
XFILLER_20_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08911__928 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1040 sky130_fd_sc_hd__inv_2
XFILLER_3_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_135 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08532__569 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__inv_2
X_10084_ net120 _01032_ VGND VGND VPWR VPWR rf\[31\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08647__678 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__inv_2
XFILLER_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_328 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08392__437 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__inv_2
XFILLER_98_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05961_ _02824_ VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__clkbuf_1
X_07700_ rf\[16\]\[30\] rf\[17\]\[30\] rf\[18\]\[30\] rf\[19\]\[30\] _03639_ _03631_
+ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__mux4_1
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05892_ rf\[20\]\[23\] _02068_ _02780_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__mux2_1
XFILLER_66_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04912_ rf\[6\]\[14\] _02086_ _02262_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__mux2_1
X_07631_ rf\[20\]\[26\] rf\[21\]\[26\] rf\[22\]\[26\] rf\[23\]\[26\] _03695_ _03696_
+ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__mux4_2
XFILLER_66_665 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04843_ _02243_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__clkbuf_1
X_07562_ _04027_ _04032_ _04041_ _03650_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__o211a_1
XFILLER_53_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09301_ net399 _01273_ VGND VGND VPWR VPWR rf\[16\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_81_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04774_ rf\[4\]\[15\] _02084_ _02190_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06513_ _03109_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__clkbuf_1
X_07493_ _03588_ _03975_ _03597_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__o21a_1
XFILLER_21_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06444_ rf\[12\]\[12\] _02090_ _03054_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__mux2_1
XFILLER_21_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09232_ net330 _01204_ VGND VGND VPWR VPWR rf\[14\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_09163_ net261 _01135_ VGND VGND VPWR VPWR rf\[11\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_06375_ _02088_ rf\[13\]\[13\] _03019_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__mux2_1
XFILLER_21_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05326_ rf\[2\]\[6\] _02102_ _02468_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__mux2_1
X_09094_ net192 _01066_ VGND VGND VPWR VPWR rf\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05257_ _02458_ VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__clkbuf_1
XFILLER_122_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05188_ _02422_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09996_ net1094 _01968_ VGND VGND VPWR VPWR rf\[4\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07829_ _03196_ _04294_ _03265_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__o21a_1
XFILLER_28_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10067_ net158 _02039_ VGND VGND VPWR VPWR rf\[31\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06160_ rf\[16\]\[21\] _02072_ _02916_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__mux2_1
X_06091_ _02891_ VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__clkbuf_1
X_05111_ rf\[8\]\[14\] _02086_ _02365_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__mux2_1
XFILLER_104_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05042_ _02347_ VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08515__553 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__inv_2
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09850_ net948 _01822_ VGND VGND VPWR VPWR rf\[7\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06993_ rf\[24\]\[27\] rf\[25\]\[27\] rf\[26\]\[27\] rf\[27\]\[27\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__mux4_1
XFILLER_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09781_ net879 _01753_ VGND VGND VPWR VPWR rf\[9\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05944_ rf\[1\]\[30\] _02054_ _02814_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__mux2_1
X_08732_ clknet_1_0__leaf__04479_ VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__buf_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05875_ _02779_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__buf_12
XFILLER_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04826_ rf\[5\]\[23\] _02068_ _02226_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__mux2_1
X_07614_ rf\[12\]\[25\] rf\[13\]\[25\] rf\[14\]\[25\] rf\[15\]\[25\] _03630_ _03613_
+ VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__mux4_1
XFILLER_53_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04757_ _02198_ VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__clkbuf_1
X_07545_ rf\[4\]\[22\] rf\[5\]\[22\] rf\[6\]\[22\] rf\[7\]\[22\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _04025_ sky130_fd_sc_hd__mux4_1
X_07476_ rf\[16\]\[18\] rf\[17\]\[18\] rf\[18\]\[18\] rf\[19\]\[18\] _03639_ _03631_
+ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__mux4_1
X_08260__312 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__inv_2
X_04688_ rf\[19\]\[24\] _02066_ _02154_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__mux2_1
X_09215_ net313 _01187_ VGND VGND VPWR VPWR rf\[13\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_06427_ _03065_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__clkbuf_1
X_09146_ net244 _01118_ VGND VGND VPWR VPWR rf\[11\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_06358_ _03029_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__clkbuf_1
X_05309_ _02485_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__clkbuf_1
X_06289_ _02068_ rf\[14\]\[23\] _02985_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__mux2_1
X_09077_ net175 _01049_ VGND VGND VPWR VPWR rf\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08375__421 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__inv_2
XFILLER_116_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09979_ net1077 _01951_ VGND VGND VPWR VPWR rf\[4\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08802__825 clknet_1_0__leaf__04489_ VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__inv_2
XFILLER_44_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08423__466 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__inv_2
XFILLER_13_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08538__575 clknet_1_1__leaf__04475_ VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__inv_2
XFILLER_4_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_716 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05660_ rf\[24\]\[6\] _02102_ _02642_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__mux2_1
XFILLER_91_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05591_ _02100_ rf\[25\]\[7\] _02607_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__mux2_1
X_04611_ rf\[3\]\[29\] _02056_ _02119_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__mux2_1
XFILLER_35_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04542_ _02075_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__clkbuf_1
X_07330_ _03815_ _03817_ _03819_ _03821_ _03623_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__a221o_1
X_08283__334 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__inv_2
X_07261_ rf\[8\]\[7\] rf\[9\]\[7\] rf\[10\]\[7\] rf\[11\]\[7\] _03604_ _03605_ VGND
+ VGND VPWR VPWR _03756_ sky130_fd_sc_hd__mux4_1
XFILLER_31_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08398__443 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__inv_2
X_06212_ _02954_ VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__clkbuf_1
X_07192_ _03587_ _03689_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__or2_1
X_06143_ _02918_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__clkbuf_1
XFILLER_105_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06074_ rf\[17\]\[31\] _02048_ _02882_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__mux2_1
XFILLER_6_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08710__738 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__inv_2
X_05025_ rf\[7\]\[24\] _02066_ _02331_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__mux2_1
X_09902_ net1000 _01874_ VGND VGND VPWR VPWR rf\[6\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09833_ net931 _01805_ VGND VGND VPWR VPWR rf\[8\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06976_ _03271_ _03483_ _03265_ VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__o21a_1
X_09764_ net862 _01736_ VGND VGND VPWR VPWR rf\[30\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05927_ _02806_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__clkbuf_1
X_09695_ net793 _01667_ VGND VGND VPWR VPWR rf\[28\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_08331__379 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__inv_2
X_05858_ _02770_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__clkbuf_1
XTAP_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04809_ _02225_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__buf_12
X_08446__488 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__inv_2
X_05789_ _02098_ rf\[22\]\[8\] _02711_ VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__mux2_1
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07528_ _03580_ _04006_ _04008_ _03595_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__o211a_1
X_07459_ _03699_ _03943_ _03594_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__o21a_1
XFILLER_6_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09129_ net227 _01101_ VGND VGND VPWR VPWR rf\[29\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08570__606 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__inv_2
XFILLER_123_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08191__247 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__inv_2
XFILLER_66_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_7 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput107 net107 VGND VGND VPWR VPWR port2_data_o[4] sky130_fd_sc_hd__buf_4
XFILLER_5_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_1__f__04483_ clknet_0__04483_ VGND VGND VPWR VPWR clknet_1_1__leaf__04483_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_122_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_621 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06830_ rf\[12\]\[19\] rf\[13\]\[19\] rf\[14\]\[19\] rf\[15\]\[19\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__mux4_1
X_06761_ rf\[24\]\[15\] rf\[25\]\[15\] rf\[26\]\[15\] rf\[27\]\[15\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__mux4_1
X_09480_ net578 _01452_ VGND VGND VPWR VPWR rf\[21\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_05712_ _02695_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__clkbuf_1
X_06692_ _03192_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__buf_12
XFILLER_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05643_ _02659_ VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__clkbuf_1
XFILLER_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08431_ clknet_1_1__leaf__04468_ VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__buf_1
XFILLER_91_593 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05574_ _02623_ VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__clkbuf_1
X_07313_ rf\[0\]\[10\] rf\[1\]\[10\] rf\[2\]\[10\] rf\[3\]\[10\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03805_ sky130_fd_sc_hd__mux4_1
X_04525_ net28 VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__buf_12
X_07244_ rf\[16\]\[6\] rf\[17\]\[6\] rf\[18\]\[6\] rf\[19\]\[6\] _03589_ _03584_ VGND
+ VGND VPWR VPWR _03740_ sky130_fd_sc_hd__mux4_1
XFILLER_117_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07175_ rf\[24\]\[3\] rf\[25\]\[3\] rf\[26\]\[3\] rf\[27\]\[3\] _03590_ _03585_ VGND
+ VGND VPWR VPWR _03674_ sky130_fd_sc_hd__mux4_2
XFILLER_11_26 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06126_ rf\[17\]\[5\] _02104_ _02881_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__mux2_1
X_06057_ _02873_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__clkbuf_1
XFILLER_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05008_ _02329_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__clkbuf_1
XFILLER_101_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09816_ net914 _01788_ VGND VGND VPWR VPWR rf\[8\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_100_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06959_ _03453_ _03458_ _03467_ _03258_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__o211a_2
X_09747_ net845 _01719_ VGND VGND VPWR VPWR rf\[30\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09678_ net776 _01650_ VGND VGND VPWR VPWR rf\[28\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_682 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08314__363 clknet_1_0__leaf__04463_ VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__inv_2
X_08808__831 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__inv_2
XFILLER_37_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08429__472 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__inv_2
XFILLER_33_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08854__873 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__inv_2
X_05290_ rf\[2\]\[24\] _02066_ _02468_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__mux2_1
XFILLER_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04466_ clknet_0__04466_ VGND VGND VPWR VPWR clknet_1_1__leaf__04466_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_102_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08174__231 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__inv_2
X_07931_ _03247_ _04390_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__or2_1
X_07862_ _03261_ _04325_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__or2_1
Xclkbuf_0__04497_ _04497_ VGND VGND VPWR VPWR clknet_0__04497_ sky130_fd_sc_hd__clkbuf_16
X_09601_ net699 _01573_ VGND VGND VPWR VPWR rf\[25\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06813_ _03271_ _03328_ _03273_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__o21a_1
X_07793_ _04260_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_1
X_09532_ net630 _01504_ VGND VGND VPWR VPWR rf\[23\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_08289__340 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__inv_2
XFILLER_37_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06744_ net2 VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__buf_12
X_09463_ net561 _01435_ VGND VGND VPWR VPWR rf\[21\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06675_ _03195_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__buf_12
X_05626_ rf\[24\]\[23\] _02068_ _02642_ VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__mux2_1
X_09394_ net492 _01366_ VGND VGND VPWR VPWR rf\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_05557_ _02066_ rf\[25\]\[24\] _02607_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__mux2_1
X_08601__635 clknet_1_1__leaf__04478_ VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__inv_2
XFILLER_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04508_ _02048_ rf\[31\]\[31\] _02052_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__mux2_1
XFILLER_20_630 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05488_ _02064_ rf\[26\]\[25\] _02572_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__mux2_1
XFILLER_22_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07227_ rf\[20\]\[5\] rf\[21\]\[5\] rf\[22\]\[5\] rf\[23\]\[5\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _03724_ sky130_fd_sc_hd__mux4_2
XFILLER_106_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07158_ _03603_ _03657_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__or2_1
X_08222__276 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__inv_2
X_06109_ _02900_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__clkbuf_1
XFILLER_121_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07089_ _03584_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__buf_12
XFILLER_78_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08337__385 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__inv_2
XFILLER_59_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_0__f__04486_ clknet_0__04486_ VGND VGND VPWR VPWR clknet_1_0__leaf__04486_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08877__895 clknet_1_0__leaf__04494_ VGND VGND VPWR VPWR net1007 sky130_fd_sc_hd__inv_2
XFILLER_11_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08082__144 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__inv_2
XFILLER_109_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08197__253 clknet_1_1__leaf__04456_ VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__inv_2
XFILLER_124_565 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_633 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04790_ rf\[4\]\[7\] _02100_ _02190_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__mux2_1
XFILLER_18_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06460_ rf\[12\]\[4\] _02106_ _03053_ VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__mux2_1
X_08130__189 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__inv_2
X_05411_ _02539_ VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06391_ _02104_ rf\[13\]\[5\] _03018_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__mux2_1
X_08245__298 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__inv_2
X_05342_ _02502_ VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__buf_12
X_05273_ _02466_ VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__clkbuf_1
X_07012_ rf\[0\]\[28\] rf\[1\]\[28\] rf\[2\]\[28\] rf\[3\]\[28\] _03251_ _03221_ VGND
+ VGND VPWR VPWR _03518_ sky130_fd_sc_hd__mux4_1
XFILLER_115_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07914_ rf\[12\]\[9\] rf\[13\]\[9\] rf\[14\]\[9\] rf\[15\]\[9\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04375_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04449_ clknet_0__04449_ VGND VGND VPWR VPWR clknet_1_1__leaf__04449_
+ sky130_fd_sc_hd__clkbuf_16
X_07845_ rf\[24\]\[5\] rf\[25\]\[5\] rf\[26\]\[5\] rf\[27\]\[5\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04310_ sky130_fd_sc_hd__mux4_1
XFILLER_71_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04988_ _02319_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__clkbuf_1
X_07776_ rf\[8\]\[2\] rf\[9\]\[2\] rf\[10\]\[2\] rf\[11\]\[2\] _03262_ _03268_ VGND
+ VGND VPWR VPWR _04244_ sky130_fd_sc_hd__mux4_2
X_09515_ net613 _01487_ VGND VGND VPWR VPWR rf\[22\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06727_ _03195_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__clkbuf_16
X_09446_ net544 _01418_ VGND VGND VPWR VPWR rf\[20\]\[24\] sky130_fd_sc_hd__dfxtp_1
XPHY_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06658_ rf\[0\]\[3\] VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__clkbuf_1
XFILLER_40_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05609_ _02641_ VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__clkbuf_16
X_06589_ _03148_ VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__clkbuf_1
X_09377_ net475 _01349_ VGND VGND VPWR VPWR rf\[18\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10083_ net119 _01031_ VGND VGND VPWR VPWR rf\[31\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04469_ clknet_0__04469_ VGND VGND VPWR VPWR clknet_1_0__leaf__04469_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08468__509 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__inv_2
XFILLER_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05960_ rf\[1\]\[22\] _02070_ _02814_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__mux2_1
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05891_ _02788_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__clkbuf_1
X_04911_ _02279_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__clkbuf_1
X_07630_ _03578_ _04105_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__or2_1
XFILLER_66_677 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04842_ rf\[5\]\[15\] _02084_ _02226_ VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__mux2_1
XFILLER_93_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07561_ _04034_ _04036_ _04038_ _04040_ _03623_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__a221o_1
XFILLER_0_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04773_ _02206_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__clkbuf_1
X_09300_ net398 _01272_ VGND VGND VPWR VPWR rf\[16\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06512_ rf\[11\]\[11\] net13 _03088_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__mux2_1
XFILLER_110_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07492_ rf\[28\]\[19\] rf\[29\]\[19\] rf\[30\]\[19\] rf\[31\]\[19\] _03583_ _03585_
+ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__mux4_2
XFILLER_22_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06443_ _03073_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__clkbuf_1
X_09231_ net329 _01203_ VGND VGND VPWR VPWR rf\[14\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_09162_ net260 _01134_ VGND VGND VPWR VPWR rf\[11\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06374_ _03037_ VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05325_ _02493_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09093_ net191 _01065_ VGND VGND VPWR VPWR rf\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_09025__29 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__inv_2
X_05256_ _02098_ rf\[30\]\[8\] _02434_ VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__mux2_1
X_05187_ rf\[9\]\[9\] _02096_ _02399_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__mux2_1
XFILLER_88_213 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09995_ net1093 _01967_ VGND VGND VPWR VPWR rf\[4\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_07992__59 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__inv_2
XFILLER_29_302 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07828_ rf\[28\]\[4\] rf\[29\]\[4\] rf\[30\]\[4\] rf\[31\]\[4\] _03207_ _03208_ VGND
+ VGND VPWR VPWR _04294_ sky130_fd_sc_hd__mux4_1
XFILLER_28_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08607__641 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__inv_2
X_07759_ rf\[24\]\[1\] rf\[25\]\[1\] rf\[26\]\[1\] rf\[27\]\[1\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _04228_ sky130_fd_sc_hd__mux4_1
X_08113__173 clknet_1_1__leaf__04452_ VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__inv_2
X_09429_ net527 _01401_ VGND VGND VPWR VPWR rf\[20\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08228__282 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__inv_2
XFILLER_9_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08653__683 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__inv_2
XFILLER_5_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_354 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10066_ net157 _02038_ VGND VGND VPWR VPWR rf\[31\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_655 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08088__150 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__inv_2
X_08892__910 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1022 sky130_fd_sc_hd__inv_2
X_08400__445 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__inv_2
X_05110_ _02382_ VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06090_ rf\[17\]\[23\] _02068_ _02882_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__mux2_1
X_05041_ rf\[7\]\[16\] _02082_ _02331_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__mux2_1
XFILLER_98_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06992_ _03247_ _03498_ _03273_ VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__o21a_1
X_09780_ net878 _01752_ VGND VGND VPWR VPWR rf\[9\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05943_ _02815_ VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__clkbuf_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08136__195 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__inv_2
XFILLER_38_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05874_ _02778_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__clkbuf_4
XFILLER_66_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07613_ _03603_ _04089_ _03682_ VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__o21a_1
X_08940__955 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1067 sky130_fd_sc_hd__inv_2
XFILLER_121_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04825_ _02234_ VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__clkbuf_1
X_07544_ rf\[0\]\[22\] rf\[1\]\[22\] rf\[2\]\[22\] rf\[3\]\[22\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _04024_ sky130_fd_sc_hd__mux4_1
X_04756_ rf\[4\]\[24\] _02066_ _02190_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__mux2_1
XFILLER_62_680 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04687_ _02161_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__clkbuf_1
XFILLER_22_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07475_ _03597_ _03956_ _03958_ _03608_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__a31o_1
X_09214_ net312 _01186_ VGND VGND VPWR VPWR rf\[13\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06426_ rf\[12\]\[21\] _02072_ _03054_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__mux2_1
X_09145_ net243 _01117_ VGND VGND VPWR VPWR rf\[11\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_06357_ _02070_ rf\[13\]\[22\] _03019_ VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__mux2_1
X_09076_ net174 _01048_ VGND VGND VPWR VPWR rf\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_05308_ rf\[2\]\[15\] _02084_ _02468_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__mux2_1
X_06288_ _02993_ VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__clkbuf_1
X_05239_ _02449_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09978_ net1076 _01950_ VGND VGND VPWR VPWR rf\[4\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_515 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_619 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_728 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08963__977 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1089 sky130_fd_sc_hd__inv_2
X_10049_ net140 _02021_ VGND VGND VPWR VPWR rf\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05590_ _02631_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__clkbuf_1
XFILLER_90_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04610_ _02121_ VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04541_ _02074_ rf\[31\]\[20\] _02052_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__mux2_1
X_07260_ _03598_ _03754_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__or2_1
X_08359__406 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__inv_2
X_06211_ _02056_ rf\[15\]\[29\] _02951_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__mux2_1
X_07191_ rf\[12\]\[4\] rf\[13\]\[4\] rf\[14\]\[4\] rf\[15\]\[4\] _03589_ _03584_ VGND
+ VGND VPWR VPWR _03689_ sky130_fd_sc_hd__mux4_1
XFILLER_117_413 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06142_ rf\[16\]\[30\] _02054_ _02916_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__mux2_1
XFILLER_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06073_ _02881_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__buf_12
X_05024_ _02338_ VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__clkbuf_1
X_09901_ net999 _01873_ VGND VGND VPWR VPWR rf\[10\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09832_ net930 _01804_ VGND VGND VPWR VPWR rf\[8\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_09763_ net861 _01735_ VGND VGND VPWR VPWR rf\[30\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06975_ rf\[28\]\[26\] rf\[29\]\[26\] rf\[30\]\[26\] rf\[31\]\[26\] _03262_ _03263_
+ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__mux4_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05926_ rf\[20\]\[6\] _02102_ _02780_ VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__mux2_1
X_09694_ net792 _01666_ VGND VGND VPWR VPWR rf\[28\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_27_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08899__916 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1028 sky130_fd_sc_hd__inv_2
X_05857_ _02100_ rf\[21\]\[7\] _02745_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__mux2_1
XFILLER_66_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04808_ _02187_ _02224_ VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__nor2_4
XFILLER_26_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05788_ _02734_ VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__clkbuf_1
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07527_ _03598_ _04007_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__or2_1
X_04739_ net45 net44 net43 VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__or3b_4
X_07458_ rf\[20\]\[17\] rf\[21\]\[17\] rf\[22\]\[17\] rf\[23\]\[17\] _03695_ _03696_
+ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__mux4_2
XFILLER_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07389_ rf\[20\]\[14\] rf\[21\]\[14\] rf\[22\]\[14\] rf\[23\]\[14\] _03582_ _03626_
+ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__mux4_2
X_06409_ _03056_ VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__clkbuf_1
XFILLER_41_24 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09128_ net226 _01100_ VGND VGND VPWR VPWR rf\[29\]\[26\] sky130_fd_sc_hd__dfxtp_2
XFILLER_2_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08986__999 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1111 sky130_fd_sc_hd__inv_2
XFILLER_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08267__319 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__inv_2
XFILLER_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput108 net108 VGND VGND VPWR VPWR port2_data_o[5] sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f__04482_ clknet_0__04482_ VGND VGND VPWR VPWR clknet_1_1__leaf__04482_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput90 net90 VGND VGND VPWR VPWR port2_data_o[18] sky130_fd_sc_hd__buf_2
XFILLER_68_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06760_ _03271_ _03278_ _03273_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__o21a_1
XFILLER_76_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05711_ _02086_ rf\[23\]\[14\] _02677_ VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__mux2_1
X_06691_ _03189_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__buf_12
X_05642_ rf\[24\]\[15\] _02084_ _02642_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__mux2_1
XFILLER_36_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05573_ _02082_ rf\[25\]\[16\] _02607_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__mux2_1
XFILLER_51_469 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08406__451 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__inv_2
X_04524_ _02063_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__clkbuf_1
X_07312_ _03804_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
XFILLER_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07243_ _03732_ _03734_ _03736_ _03738_ _03608_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__a221o_1
XFILLER_117_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07174_ _03629_ _03672_ VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__or2_1
XFILLER_11_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06125_ _02908_ VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__clkbuf_1
X_08831__852 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__inv_2
XFILLER_105_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06056_ rf\[18\]\[7\] _02100_ _02848_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__mux2_1
XFILLER_120_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05007_ rf\[10\]\[0\] _02114_ _02296_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__mux2_1
XFILLER_86_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09815_ net913 _01787_ VGND VGND VPWR VPWR rf\[8\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_08452__493 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__inv_2
X_08946__961 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1073 sky130_fd_sc_hd__inv_2
XFILLER_86_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06958_ _03460_ _03462_ _03464_ _03466_ _03231_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__a221o_1
X_09746_ net844 _01718_ VGND VGND VPWR VPWR rf\[30\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05909_ _02797_ VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__clkbuf_1
X_09677_ net775 _01649_ VGND VGND VPWR VPWR rf\[27\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06889_ rf\[8\]\[22\] rf\[9\]\[22\] rf\[10\]\[22\] rf\[11\]\[22\] _03212_ _03221_
+ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__mux4_1
XTAP_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_694 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08691__720 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__inv_2
XFILLER_108_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_510 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_414 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08815__836 clknet_1_1__leaf__04491_ VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__inv_2
XFILLER_54_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07930_ rf\[4\]\[10\] rf\[5\]\[10\] rf\[6\]\[10\] rf\[7\]\[10\] _03254_ _03199_ VGND
+ VGND VPWR VPWR _04390_ sky130_fd_sc_hd__mux4_1
X_08969__983 clknet_1_0__leaf__04498_ VGND VGND VPWR VPWR net1095 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04465_ clknet_0__04465_ VGND VGND VPWR VPWR clknet_1_1__leaf__04465_
+ sky130_fd_sc_hd__clkbuf_16
X_07861_ rf\[16\]\[6\] rf\[17\]\[6\] rf\[18\]\[6\] rf\[19\]\[6\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _04325_ sky130_fd_sc_hd__mux4_1
Xclkbuf_0__04496_ _04496_ VGND VGND VPWR VPWR clknet_0__04496_ sky130_fd_sc_hd__clkbuf_16
X_09600_ net698 _01572_ VGND VGND VPWR VPWR rf\[25\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_07792_ _03220_ _04250_ _04259_ VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__and3_4
XFILLER_3_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06812_ rf\[4\]\[18\] rf\[5\]\[18\] rf\[6\]\[18\] rf\[7\]\[18\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _03328_ sky130_fd_sc_hd__mux4_1
X_09531_ net629 _01503_ VGND VGND VPWR VPWR rf\[23\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_06743_ _03189_ VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__buf_12
XFILLER_52_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09462_ net560 _01434_ VGND VGND VPWR VPWR rf\[21\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_06674_ _03187_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__inv_4
XFILLER_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05625_ _02650_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__clkbuf_1
X_09393_ net491 _01365_ VGND VGND VPWR VPWR rf\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_05556_ _02614_ VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__clkbuf_1
XFILLER_51_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04507_ _02051_ VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__buf_12
XFILLER_20_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08675__704 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__inv_2
X_05487_ _02578_ VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_675 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07226_ _03629_ _03722_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__or2_1
XFILLER_106_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07157_ rf\[8\]\[2\] rf\[9\]\[2\] rf\[10\]\[2\] rf\[11\]\[2\] _03604_ _03605_ VGND
+ VGND VPWR VPWR _03657_ sky130_fd_sc_hd__mux4_1
X_06108_ rf\[17\]\[14\] _02086_ _02882_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__mux2_1
X_07088_ _03589_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__buf_12
X_06039_ _02864_ VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__clkbuf_1
XFILLER_87_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09729_ net827 _01701_ VGND VGND VPWR VPWR rf\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_62_509 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08762__787 clknet_1_0__leaf__04487_ VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__inv_2
XFILLER_15_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04485_ clknet_0__04485_ VGND VGND VPWR VPWR clknet_1_0__leaf__04485_
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08838__858 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__inv_2
X_08043__107 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__inv_2
XFILLER_7_602 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09046__49 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__inv_2
X_07998__65 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__inv_2
X_08158__216 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__inv_2
XFILLER_124_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08698__726 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__inv_2
X_05410_ _02048_ rf\[27\]\[31\] _02538_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__mux2_1
XTAP_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06390_ _03045_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__clkbuf_1
X_05341_ _02049_ _02501_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__nand2_4
X_05272_ _02114_ rf\[30\]\[0\] _02433_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__mux2_1
X_07011_ _03211_ _03516_ _03265_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__o21a_1
XFILLER_108_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_1_1__f__04448_ clknet_0__04448_ VGND VGND VPWR VPWR clknet_1_1__leaf__04448_
+ sky130_fd_sc_hd__clkbuf_16
X_07913_ _03188_ _04371_ _04373_ _03203_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__o211a_1
X_08893_ clknet_1_1__leaf__04490_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__buf_1
X_07844_ _03271_ _04308_ _03202_ VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__o21a_1
XFILLER_69_686 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0__04479_ _04479_ VGND VGND VPWR VPWR clknet_0__04479_ sky130_fd_sc_hd__clkbuf_16
XFILLER_56_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04987_ rf\[10\]\[10\] _02094_ _02297_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__mux2_1
XFILLER_17_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07775_ _03195_ _04242_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__or2_1
X_09514_ net612 _01486_ VGND VGND VPWR VPWR rf\[22\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06726_ _03242_ _03245_ VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__or2_1
XFILLER_24_200 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09445_ net543 _01417_ VGND VGND VPWR VPWR rf\[20\]\[23\] sky130_fd_sc_hd__dfxtp_1
XPHY_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06657_ _03182_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05608_ _02640_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__clkbuf_4
XFILLER_52_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08066__129 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__inv_2
XFILLER_33_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09376_ net474 _01348_ VGND VGND VPWR VPWR rf\[18\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06588_ _02102_ rf\[29\]\[6\] _03122_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__mux2_1
X_05539_ _02604_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__clkbuf_1
XFILLER_118_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07209_ rf\[24\]\[4\] rf\[25\]\[4\] rf\[26\]\[4\] rf\[27\]\[4\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03707_ sky130_fd_sc_hd__mux4_1
X_08189_ clknet_1_0__leaf__04446_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__buf_1
X_10082_ net118 _01030_ VGND VGND VPWR VPWR rf\[31\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_689 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04468_ clknet_0__04468_ VGND VGND VPWR VPWR clknet_1_0__leaf__04468_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_90_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08205__261 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__inv_2
XFILLER_99_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08630__662 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__inv_2
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04910_ rf\[6\]\[15\] _02084_ _02262_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__mux2_1
X_05890_ rf\[20\]\[24\] _02066_ _02780_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__mux2_1
XFILLER_65_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_306 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04841_ _02242_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__clkbuf_1
X_07560_ _03588_ _04039_ _03693_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__o21a_1
X_08745__771 clknet_1_1__leaf__04486_ VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__inv_2
X_04772_ rf\[4\]\[16\] _02082_ _02190_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__mux2_1
X_06511_ _03108_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__clkbuf_1
X_07491_ _03580_ _03973_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__or2_1
X_09230_ net328 _01202_ VGND VGND VPWR VPWR rf\[14\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_34_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06442_ rf\[12\]\[13\] _02088_ _03054_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__mux2_1
XFILLER_22_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09161_ net259 _01133_ VGND VGND VPWR VPWR rf\[11\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06373_ _02086_ rf\[13\]\[14\] _03019_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__mux2_1
XFILLER_119_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09092_ net190 _01064_ VGND VGND VPWR VPWR rf\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_05324_ rf\[2\]\[7\] _02100_ _02468_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__mux2_1
X_05255_ _02457_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__clkbuf_1
X_08490__530 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__inv_2
XFILLER_89_704 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05186_ _02421_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__clkbuf_1
XFILLER_88_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09994_ net1092 _01966_ VGND VGND VPWR VPWR rf\[4\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07827_ _03242_ _04292_ VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__or2_1
XFILLER_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07758_ _03242_ _04226_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__or2_2
X_06709_ net5 VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__inv_2
XFILLER_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07689_ _03579_ _04161_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__or2_1
X_09428_ net526 _01400_ VGND VGND VPWR VPWR rf\[20\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_09359_ net457 _01331_ VGND VGND VPWR VPWR rf\[18\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08614__646 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__inv_2
XFILLER_79_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10065_ net156 _02037_ VGND VGND VPWR VPWR rf\[31\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_08768__793 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__inv_2
XFILLER_47_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08474__514 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__inv_2
X_05040_ _02346_ VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__clkbuf_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06991_ rf\[20\]\[27\] rf\[21\]\[27\] rf\[22\]\[27\] rf\[23\]\[27\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__mux4_1
XFILLER_105_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05942_ rf\[1\]\[31\] _02048_ _02814_ VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__mux2_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05873_ _02501_ _02675_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__and2_1
XFILLER_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07612_ rf\[0\]\[25\] rf\[1\]\[25\] rf\[2\]\[25\] rf\[3\]\[25\] _03662_ _03605_ VGND
+ VGND VPWR VPWR _04089_ sky130_fd_sc_hd__mux4_1
X_04824_ rf\[5\]\[24\] _02066_ _02226_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__mux2_1
XFILLER_81_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08901__918 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1030 sky130_fd_sc_hd__inv_2
XFILLER_81_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07543_ _04009_ _04014_ _04023_ _03650_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__o211a_1
X_04755_ _02197_ VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04686_ rf\[19\]\[25\] _02064_ _02154_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__mux2_1
X_07474_ _03603_ _03957_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__or2_1
X_08561__597 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__inv_2
XFILLER_14_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09213_ net311 _01185_ VGND VGND VPWR VPWR rf\[13\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_06425_ _03064_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__clkbuf_1
X_09144_ net242 _01116_ VGND VGND VPWR VPWR rf\[11\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06356_ _03028_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__clkbuf_1
X_08637__668 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__inv_2
X_05307_ _02484_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__clkbuf_1
X_09075_ net173 _01047_ VGND VGND VPWR VPWR rf\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06287_ _02066_ rf\[14\]\[24\] _02985_ VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__mux2_1
X_05238_ _02080_ rf\[30\]\[17\] _02434_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__mux2_1
XFILLER_89_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05169_ rf\[9\]\[18\] _02078_ _02399_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__mux2_1
XFILLER_77_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09977_ net1075 _01949_ VGND VGND VPWR VPWR rf\[4\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08497__536 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__inv_2
XFILLER_9_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10048_ net139 _02020_ VGND VGND VPWR VPWR rf\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04540_ net23 VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__buf_12
XFILLER_44_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06210_ _02953_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__clkbuf_1
X_07190_ _03623_ _03678_ _03688_ _03650_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__o211a_1
XFILLER_117_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06141_ _02917_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06072_ _02152_ _02224_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__nor2_4
X_05023_ rf\[7\]\[25\] _02064_ _02331_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__mux2_1
X_09900_ net998 _01872_ VGND VGND VPWR VPWR rf\[10\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_116_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09831_ net929 _01803_ VGND VGND VPWR VPWR rf\[8\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08784__808 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__inv_2
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09762_ net860 _01734_ VGND VGND VPWR VPWR rf\[30\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_06974_ _03261_ _03481_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__or2_1
XFILLER_86_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05925_ _02805_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__clkbuf_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09693_ net791 _01665_ VGND VGND VPWR VPWR rf\[28\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_475 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05856_ _02769_ VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__clkbuf_1
X_05787_ _02096_ rf\[22\]\[9\] _02711_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__mux2_1
XTAP_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04807_ net45 _02223_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__or2_4
XFILLER_42_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04738_ net48 net47 net46 VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__or3b_4
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07526_ rf\[4\]\[21\] rf\[5\]\[21\] rf\[6\]\[21\] rf\[7\]\[21\] _03646_ _03591_ VGND
+ VGND VPWR VPWR _04007_ sky130_fd_sc_hd__mux4_1
XFILLER_22_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07457_ _03578_ _03941_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__or2_1
X_04669_ rf\[3\]\[0\] _02114_ _02118_ VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__mux2_1
XFILLER_50_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07388_ _03862_ _03867_ _03876_ _03650_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__o211a_1
X_06408_ rf\[12\]\[30\] _02054_ _03054_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__mux2_1
XFILLER_41_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09127_ net225 _01099_ VGND VGND VPWR VPWR rf\[29\]\[25\] sky130_fd_sc_hd__dfxtp_2
X_06339_ _02048_ rf\[13\]\[31\] _03019_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__mux2_1
XFILLER_123_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08009_ clknet_1_1__leaf__04446_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__buf_1
XFILLER_116_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08544__581 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__inv_2
XFILLER_41_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput109 net109 VGND VGND VPWR VPWR port2_data_o[6] sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f__04481_ clknet_0__04481_ VGND VGND VPWR VPWR clknet_1_1__leaf__04481_
+ sky130_fd_sc_hd__clkbuf_16
Xoutput80 net80 VGND VGND VPWR VPWR port1_data_o[9] sky130_fd_sc_hd__buf_2
Xoutput91 net91 VGND VGND VPWR VPWR port2_data_o[19] sky130_fd_sc_hd__buf_2
XFILLER_110_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05710_ _02694_ VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__clkbuf_1
X_06690_ _03187_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__buf_8
X_05641_ _02658_ VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__clkbuf_1
XFILLER_91_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05572_ _02622_ VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07311_ _03612_ _03794_ _03803_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__and3_4
X_04523_ _02062_ rf\[31\]\[26\] _02052_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__mux2_1
XFILLER_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07242_ _03699_ _03737_ _03682_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__o21a_1
XFILLER_118_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07173_ rf\[16\]\[3\] rf\[17\]\[3\] rf\[18\]\[3\] rf\[19\]\[3\] _03630_ _03631_ VGND
+ VGND VPWR VPWR _03672_ sky130_fd_sc_hd__mux4_1
X_06124_ rf\[17\]\[6\] _02102_ _02882_ VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__mux2_1
X_06055_ _02872_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__clkbuf_1
XFILLER_99_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05006_ _02328_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__clkbuf_1
XFILLER_98_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09814_ net912 _01786_ VGND VGND VPWR VPWR rf\[8\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_08413__456 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__inv_2
XFILLER_98_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08907__924 clknet_1_1__leaf__04495_ VGND VGND VPWR VPWR net1036 sky130_fd_sc_hd__inv_2
XFILLER_86_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06957_ _03196_ _03465_ _03265_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__o21a_1
X_09745_ net843 _01717_ VGND VGND VPWR VPWR rf\[30\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_09676_ net774 _01648_ VGND VGND VPWR VPWR rf\[27\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_05908_ rf\[20\]\[15\] _02084_ _02780_ VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__mux2_1
XFILLER_36_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06888_ _03206_ _03399_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__or2_1
X_05839_ _02082_ rf\[21\]\[16\] _02745_ VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__mux2_1
XTAP_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_448 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07509_ rf\[0\]\[20\] rf\[1\]\[20\] rf\[2\]\[20\] rf\[3\]\[20\] _03695_ _03696_ VGND
+ VGND VPWR VPWR _03991_ sky130_fd_sc_hd__mux4_2
XFILLER_52_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08273__324 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__inv_2
XFILLER_77_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08700__728 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__inv_2
XFILLER_5_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08436__478 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__inv_2
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_1_1__f__04464_ clknet_0__04464_ VGND VGND VPWR VPWR clknet_1_1__leaf__04464_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07860_ _03205_ _04321_ _04323_ _03216_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__a31o_1
Xclkbuf_0__04495_ _04495_ VGND VGND VPWR VPWR clknet_0__04495_ sky130_fd_sc_hd__clkbuf_16
XFILLER_95_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07791_ _04252_ _04254_ _04256_ _04258_ _03230_ VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__a221o_1
X_06811_ _03261_ _03326_ VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__or2_1
X_09530_ net628 _01502_ VGND VGND VPWR VPWR rf\[23\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_497 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06742_ _03187_ VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__buf_8
XFILLER_49_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09461_ net559 _01433_ VGND VGND VPWR VPWR rf\[21\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06673_ rf\[0\]\[13\] rf\[1\]\[13\] rf\[2\]\[13\] rf\[3\]\[13\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _03194_ sky130_fd_sc_hd__mux4_1
XFILLER_52_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05624_ rf\[24\]\[24\] _02066_ _02642_ VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__mux2_1
X_09392_ net490 _01364_ VGND VGND VPWR VPWR rf\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_05555_ _02064_ rf\[25\]\[25\] _02607_ VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__mux2_1
X_04506_ _02049_ _02050_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__nand2_4
X_05486_ _02062_ rf\[26\]\[26\] _02572_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__mux2_1
X_07225_ rf\[16\]\[5\] rf\[17\]\[5\] rf\[18\]\[5\] rf\[19\]\[5\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03722_ sky130_fd_sc_hd__mux4_1
XFILLER_20_654 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_687 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08296__346 clknet_1_0__leaf__04462_ VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__inv_2
X_07156_ _03598_ _03655_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__or2_1
XFILLER_106_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06107_ _02899_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__clkbuf_1
X_07087_ _03581_ VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__buf_12
XFILLER_105_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06038_ rf\[18\]\[16\] _02082_ _02848_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__mux2_1
XFILLER_121_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09728_ net826 _01700_ VGND VGND VPWR VPWR rf\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09659_ net757 _01631_ VGND VGND VPWR VPWR rf\[27\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0__f__04484_ clknet_0__04484_ VGND VGND VPWR VPWR clknet_1_0__leaf__04484_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_8_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08583__618 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__inv_2
XFILLER_93_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_521 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05340_ _02188_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__clkinv_4
X_09054__2 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__inv_2
X_05271_ _02465_ VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__clkbuf_1
X_07010_ rf\[8\]\[28\] rf\[9\]\[28\] rf\[10\]\[28\] rf\[11\]\[28\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__mux4_1
XFILLER_5_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04447_ clknet_0__04447_ VGND VGND VPWR VPWR clknet_1_1__leaf__04447_
+ sky130_fd_sc_hd__clkbuf_16
X_07912_ _03247_ _04372_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__or2_1
XFILLER_110_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0__04478_ _04478_ VGND VGND VPWR VPWR clknet_0__04478_ sky130_fd_sc_hd__clkbuf_16
X_07843_ rf\[20\]\[5\] rf\[21\]\[5\] rf\[22\]\[5\] rf\[23\]\[5\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _04308_ sky130_fd_sc_hd__mux4_1
XFILLER_96_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_698 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04986_ _02318_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__clkbuf_1
X_07774_ rf\[12\]\[2\] rf\[13\]\[2\] rf\[14\]\[2\] rf\[15\]\[2\] _03197_ _03192_ VGND
+ VGND VPWR VPWR _04242_ sky130_fd_sc_hd__mux4_2
X_09513_ net611 _01485_ VGND VGND VPWR VPWR rf\[22\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_06725_ rf\[16\]\[14\] rf\[17\]\[14\] rf\[18\]\[14\] rf\[19\]\[14\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__mux4_2
XFILLER_71_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09444_ net542 _01416_ VGND VGND VPWR VPWR rf\[20\]\[22\] sky130_fd_sc_hd__dfxtp_1
XPHY_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06656_ rf\[0\]\[4\] VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__clkbuf_1
XFILLER_24_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05607_ _02501_ _02536_ VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__and2_1
XFILLER_52_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06587_ _03147_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__clkbuf_1
X_09375_ net473 _01347_ VGND VGND VPWR VPWR rf\[18\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_05538_ _02114_ rf\[26\]\[0\] _02571_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__mux2_1
X_05469_ _02568_ VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__clkbuf_1
X_08343__391 clknet_1_1__leaf__04464_ VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__inv_2
XFILLER_125_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07208_ _03699_ _03705_ _03682_ VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__o21a_1
XFILLER_118_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07139_ rf\[4\]\[1\] rf\[5\]\[1\] rf\[6\]\[1\] rf\[7\]\[1\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _03640_ sky130_fd_sc_hd__mux4_1
X_08419__462 clknet_1_1__leaf__04469_ VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__inv_2
X_10081_ net117 _01029_ VGND VGND VPWR VPWR rf\[31\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_543 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04467_ clknet_0__04467_ VGND VGND VPWR VPWR clknet_1_0__leaf__04467_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_90_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08997__1009 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1121 sky130_fd_sc_hd__inv_2
X_08279__330 clknet_1_1__leaf__04461_ VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__inv_2
XFILLER_109_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_570 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04840_ rf\[5\]\[16\] _02082_ _02226_ VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__mux2_1
X_08706__734 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__inv_2
XFILLER_53_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08212__266 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__inv_2
X_04771_ _02205_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__clkbuf_1
X_07490_ rf\[24\]\[19\] rf\[25\]\[19\] rf\[26\]\[19\] rf\[27\]\[19\] _03590_ _03591_
+ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__mux4_1
XFILLER_0_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06510_ rf\[11\]\[12\] net14 _03088_ VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__mux2_1
X_06441_ _03072_ VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09160_ net258 _01132_ VGND VGND VPWR VPWR rf\[11\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_06372_ _03036_ VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__clkbuf_1
X_05323_ _02492_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__clkbuf_1
X_09091_ net189 _01063_ VGND VGND VPWR VPWR rf\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_05254_ _02096_ rf\[30\]\[9\] _02434_ VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__mux2_1
X_05185_ rf\[9\]\[10\] _02094_ _02399_ VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__mux2_1
XFILLER_89_716 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09993_ net1091 _01965_ VGND VGND VPWR VPWR rf\[4\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_08566__602 clknet_1_0__leaf__04476_ VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__inv_2
X_08072__134 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__inv_2
X_07826_ rf\[24\]\[4\] rf\[25\]\[4\] rf\[26\]\[4\] rf\[27\]\[4\] _03251_ _03221_ VGND
+ VGND VPWR VPWR _04292_ sky130_fd_sc_hd__mux4_1
XFILLER_56_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07757_ rf\[16\]\[1\] rf\[17\]\[1\] rf\[18\]\[1\] rf\[19\]\[1\] _03243_ _03244_ VGND
+ VGND VPWR VPWR _04226_ sky130_fd_sc_hd__mux4_1
XFILLER_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04969_ rf\[10\]\[19\] _02076_ _02297_ VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__mux2_1
X_06708_ _03196_ _03228_ _03205_ VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__o21a_1
X_07688_ rf\[16\]\[29\] rf\[17\]\[29\] rf\[18\]\[29\] rf\[19\]\[29\] _03582_ _03626_
+ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__mux4_1
XFILLER_40_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09427_ net525 _01399_ VGND VGND VPWR VPWR rf\[20\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06639_ _03173_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__clkbuf_1
XFILLER_9_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09358_ net456 _01330_ VGND VGND VPWR VPWR rf\[18\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_60_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09289_ net387 _01261_ VGND VGND VPWR VPWR rf\[15\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08729__756 clknet_1_1__leaf__04485_ VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__inv_2
X_08235__288 clknet_1_0__leaf__04459_ VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__inv_2
X_10064_ net155 _02036_ VGND VGND VPWR VPWR rf\[31\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08589__624 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__inv_2
X_08095__156 clknet_1_0__leaf__04451_ VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__inv_2
XFILLER_3_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06990_ _03242_ _03496_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__or2_1
X_09030__34 clknet_1_0__leaf__04501_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__inv_2
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05941_ _02813_ VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__buf_12
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05872_ _02777_ VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04823_ _02233_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__clkbuf_1
X_07611_ _03625_ _04087_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__or2_1
X_08591_ clknet_1_0__leaf__04468_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__buf_1
XFILLER_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07542_ _04016_ _04018_ _04020_ _04022_ _03623_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__a221o_1
XFILLER_34_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04754_ rf\[4\]\[25\] _02064_ _02190_ VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__mux2_1
X_04685_ _02160_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__clkbuf_1
X_07473_ rf\[8\]\[18\] rf\[9\]\[18\] rf\[10\]\[18\] rf\[11\]\[18\] _03604_ _03613_
+ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__mux4_1
XFILLER_22_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09212_ net310 _01184_ VGND VGND VPWR VPWR rf\[13\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_06424_ rf\[12\]\[22\] _02070_ _03054_ VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__mux2_1
X_09143_ net241 _01115_ VGND VGND VPWR VPWR rf\[11\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_06355_ _02068_ rf\[13\]\[23\] _03019_ VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__mux2_1
X_05306_ rf\[2\]\[16\] _02082_ _02468_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__mux2_1
XFILLER_108_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09074_ net172 _01046_ VGND VGND VPWR VPWR rf\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_06286_ _02992_ VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__clkbuf_1
X_05237_ _02448_ VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__clkbuf_1
XFILLER_89_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05168_ _02412_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__clkbuf_1
X_09976_ net1074 _01948_ VGND VGND VPWR VPWR rf\[4\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_05099_ rf\[8\]\[20\] _02074_ _02365_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__mux2_1
X_08996__1008 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1120 sky130_fd_sc_hd__inv_2
XFILLER_85_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_134 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07809_ rf\[28\]\[3\] rf\[29\]\[3\] rf\[30\]\[3\] rf\[31\]\[3\] _03254_ _03208_ VGND
+ VGND VPWR VPWR _04276_ sky130_fd_sc_hd__mux4_1
XFILLER_55_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_627 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08382__428 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__inv_2
XFILLER_13_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10047_ net138 _02019_ VGND VGND VPWR VPWR rf\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06140_ rf\[16\]\[31\] _02048_ _02916_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__mux2_1
X_06071_ _02880_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__clkbuf_1
X_05022_ _02337_ VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09830_ net928 _01802_ VGND VGND VPWR VPWR rf\[8\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_06973_ rf\[24\]\[26\] rf\[25\]\[26\] rf\[26\]\[26\] rf\[27\]\[26\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__mux4_1
X_09761_ net859 _01733_ VGND VGND VPWR VPWR rf\[30\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08218__272 clknet_1_0__leaf__04458_ VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__inv_2
XFILLER_112_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05924_ rf\[20\]\[7\] _02100_ _02780_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__mux2_1
X_08712_ clknet_1_1__leaf__04479_ VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__buf_1
XFILLER_67_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09692_ net790 _01664_ VGND VGND VPWR VPWR rf\[28\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05855_ _02098_ rf\[21\]\[8\] _02745_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__mux2_1
XFILLER_94_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05786_ _02733_ VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__clkbuf_1
XTAP_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04806_ net44 net43 VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__nand2_2
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04737_ _02186_ VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__clkbuf_1
X_07525_ rf\[0\]\[21\] rf\[1\]\[21\] rf\[2\]\[21\] rf\[3\]\[21\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _04006_ sky130_fd_sc_hd__mux4_1
X_07456_ rf\[16\]\[17\] rf\[17\]\[17\] rf\[18\]\[17\] rf\[19\]\[17\] _03589_ _03584_
+ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__mux4_1
X_04668_ _02150_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_10_516 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07387_ _03869_ _03871_ _03873_ _03875_ _03623_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__a221o_1
X_04599_ _02113_ VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_10_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06407_ _03055_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__clkbuf_1
X_09126_ net224 _01098_ VGND VGND VPWR VPWR rf\[29\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_06338_ _03018_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__buf_12
X_06269_ _02114_ rf\[15\]\[0\] _02950_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__mux2_1
X_08008_ clknet_1_0__leaf__04443_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__buf_1
XFILLER_89_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08078__140 clknet_1_0__leaf__04450_ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__inv_2
XFILLER_2_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08882__900 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1012 sky130_fd_sc_hd__inv_2
X_09959_ net1057 _01931_ VGND VGND VPWR VPWR rf\[5\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_468 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08505__544 clknet_1_0__leaf__04473_ VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__inv_2
XFILLER_41_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_470 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04480_ clknet_0__04480_ VGND VGND VPWR VPWR clknet_1_1__leaf__04480_
+ sky130_fd_sc_hd__clkbuf_16
Xoutput70 net70 VGND VGND VPWR VPWR port1_data_o[29] sky130_fd_sc_hd__buf_6
XFILLER_122_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput81 net81 VGND VGND VPWR VPWR port2_data_o[0] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR port2_data_o[1] sky130_fd_sc_hd__buf_4
XFILLER_110_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05640_ rf\[24\]\[16\] _02082_ _02642_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__mux2_1
X_08365__412 clknet_1_1__leaf__04465_ VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__inv_2
XFILLER_36_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05571_ _02080_ rf\[25\]\[17\] _02607_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__mux2_1
XFILLER_63_287 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07310_ _03796_ _03798_ _03800_ _03802_ _03623_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__a221o_1
X_04522_ net29 VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__buf_12
X_09067__15 clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__inv_2
X_08290_ clknet_1_0__leaf__04457_ VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__buf_1
X_08995__1007 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1119 sky130_fd_sc_hd__inv_2
X_07241_ rf\[4\]\[6\] rf\[5\]\[6\] rf\[6\]\[6\] rf\[7\]\[6\] _03582_ _03626_ VGND
+ VGND VPWR VPWR _03737_ sky130_fd_sc_hd__mux4_2
XFILLER_118_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07172_ _03625_ _03670_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__or2_1
X_06123_ _02907_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__clkbuf_1
X_06054_ rf\[18\]\[8\] _02098_ _02848_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__mux2_1
XFILLER_99_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05005_ rf\[10\]\[1\] _02112_ _02296_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__mux2_1
XFILLER_113_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09813_ net911 _01785_ VGND VGND VPWR VPWR rf\[8\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06956_ rf\[28\]\[25\] rf\[29\]\[25\] rf\[30\]\[25\] rf\[31\]\[25\] _03254_ _03199_
+ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__mux4_1
X_09744_ net842 _01716_ VGND VGND VPWR VPWR rf\[30\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_05907_ _02796_ VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__clkbuf_1
X_09675_ net773 _01647_ VGND VGND VPWR VPWR rf\[27\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06887_ rf\[12\]\[22\] rf\[13\]\[22\] rf\[14\]\[22\] rf\[15\]\[22\] _03207_ _03208_
+ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__mux4_1
X_05838_ _02760_ VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__clkbuf_1
X_08528__566 clknet_1_1__leaf__04474_ VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__inv_2
XFILLER_36_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05769_ _02078_ rf\[22\]\[18\] _02711_ VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__mux2_1
X_07508_ _03579_ _03989_ net9 VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__o21a_1
X_07439_ rf\[20\]\[16\] rf\[21\]\[16\] rf\[22\]\[16\] rf\[23\]\[16\] _03662_ _03605_
+ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__mux4_1
XFILLER_6_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09109_ net207 _01081_ VGND VGND VPWR VPWR rf\[29\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_567 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08388__434 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__inv_2
XFILLER_18_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04463_ clknet_0__04463_ VGND VGND VPWR VPWR clknet_1_1__leaf__04463_
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0__04494_ _04494_ VGND VGND VPWR VPWR clknet_0__04494_ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07790_ _03271_ _04257_ _03265_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__o21a_1
X_06810_ rf\[0\]\[18\] rf\[1\]\[18\] rf\[2\]\[18\] rf\[3\]\[18\] _03267_ _03268_ VGND
+ VGND VPWR VPWR _03326_ sky130_fd_sc_hd__mux4_2
X_06741_ _03195_ _03259_ VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__or2_1
X_09460_ net558 _01432_ VGND VGND VPWR VPWR rf\[21\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08411_ clknet_1_1__leaf__04468_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__buf_1
X_06672_ _03192_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__buf_12
XFILLER_52_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05623_ _02649_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__clkbuf_1
XFILLER_91_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09391_ net489 _01363_ VGND VGND VPWR VPWR rf\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05554_ _02613_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__clkbuf_1
X_08976__989 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1101 sky130_fd_sc_hd__inv_2
XFILLER_32_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05485_ _02577_ VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__clkbuf_1
X_04505_ net45 net44 net43 VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__and3_4
X_08181__238 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__inv_2
X_07224_ _03597_ _03718_ _03720_ _03608_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__a31o_1
XFILLER_20_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07155_ rf\[12\]\[2\] rf\[13\]\[2\] rf\[14\]\[2\] rf\[15\]\[2\] _03599_ _03600_ VGND
+ VGND VPWR VPWR _03655_ sky130_fd_sc_hd__mux4_1
XFILLER_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06106_ rf\[17\]\[15\] _02084_ _02882_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__mux2_1
X_08257__309 clknet_1_1__leaf__04460_ VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__inv_2
X_07086_ _03587_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__buf_8
X_06037_ _02863_ VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__clkbuf_1
XFILLER_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07988_ clknet_1_0__leaf__04444_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__buf_1
XFILLER_47_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06939_ _03220_ _03439_ _03448_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__and3_4
X_09727_ net825 _01699_ VGND VGND VPWR VPWR rf\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09658_ net756 _01630_ VGND VGND VPWR VPWR rf\[27\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09589_ net687 _01561_ VGND VGND VPWR VPWR rf\[25\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_596 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04483_ clknet_0__04483_ VGND VGND VPWR VPWR clknet_1_0__leaf__04483_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_11_633 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08994__1006 clknet_1_0__leaf__04500_ VGND VGND VPWR VPWR net1118 sky130_fd_sc_hd__inv_2
XFILLER_93_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08821__842 clknet_1_1__leaf__04491_ VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__inv_2
XFILLER_21_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_307 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08936__951 clknet_1_0__leaf__04497_ VGND VGND VPWR VPWR net1063 sky130_fd_sc_hd__inv_2
XFILLER_14_493 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05270_ _02112_ rf\[30\]\[1\] _02433_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__mux2_1
X_08141__200 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__inv_2
X_07989__56 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__inv_2
XFILLER_6_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07911_ rf\[4\]\[9\] rf\[5\]\[9\] rf\[6\]\[9\] rf\[7\]\[9\] _03254_ _03199_ VGND
+ VGND VPWR VPWR _04372_ sky130_fd_sc_hd__mux4_1
Xclkbuf_1_1__f__04446_ clknet_0__04446_ VGND VGND VPWR VPWR clknet_1_1__leaf__04446_
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0__04477_ _04477_ VGND VGND VPWR VPWR clknet_0__04477_ sky130_fd_sc_hd__clkbuf_16
X_07842_ _03187_ _04306_ VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__or2_1
X_09512_ net610 _01484_ VGND VGND VPWR VPWR rf\[22\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_07773_ _03231_ _04232_ _04241_ _03258_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__o211a_4
X_08681__710 clknet_1_1__leaf__04483_ VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__inv_2
X_08020__85 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__inv_2
X_04985_ rf\[10\]\[11\] _02092_ _02297_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__mux2_1
X_06724_ net2 VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__buf_12
XFILLER_25_703 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09443_ net541 _01415_ VGND VGND VPWR VPWR rf\[20\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_06655_ _03181_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__clkbuf_1
X_05606_ _02639_ VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__clkbuf_1
XPHY_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09374_ net472 _01346_ VGND VGND VPWR VPWR rf\[18\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06586_ _02100_ rf\[29\]\[7\] _03122_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__mux2_1
X_05537_ _02603_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__clkbuf_1
X_05468_ _02110_ rf\[27\]\[2\] _02537_ VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__mux2_1
X_08304__354 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__inv_2
X_07207_ rf\[20\]\[4\] rf\[21\]\[4\] rf\[22\]\[4\] rf\[23\]\[4\] _03691_ _03696_ VGND
+ VGND VPWR VPWR _03705_ sky130_fd_sc_hd__mux4_1
X_05399_ _02108_ rf\[28\]\[3\] _02502_ VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__mux2_1
XFILLER_3_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07138_ _03581_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__buf_12
XFILLER_121_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07069_ _03247_ _03571_ _03273_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__o21a_1
XFILLER_79_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09051__54 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__inv_2
X_10080_ net116 _01028_ VGND VGND VPWR VPWR rf\[31\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_59_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08844__864 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__inv_2
XFILLER_90_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_522 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08959__973 clknet_1_1__leaf__04498_ VGND VGND VPWR VPWR net1085 sky130_fd_sc_hd__inv_2
XFILLER_43_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f__04466_ clknet_0__04466_ VGND VGND VPWR VPWR clknet_1_0__leaf__04466_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_90_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08164__222 clknet_1_0__leaf__04454_ VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__inv_2
XFILLER_23_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_549 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04770_ rf\[4\]\[17\] _02080_ _02190_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__mux2_1
XFILLER_34_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06440_ rf\[12\]\[14\] _02086_ _03054_ VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__mux2_1
XFILLER_34_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08327__376 clknet_1_1__leaf__04463_ VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__inv_2
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06371_ _02084_ rf\[13\]\[15\] _03019_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__mux2_1
XFILLER_119_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09090_ net188 _01062_ VGND VGND VPWR VPWR rf\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_05322_ rf\[2\]\[8\] _02098_ _02468_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__mux2_1
XFILLER_119_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05253_ _02456_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__clkbuf_1
X_05184_ _02420_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__clkbuf_1
X_09992_ net1090 _01964_ VGND VGND VPWR VPWR rf\[4\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08867__886 clknet_1_1__leaf__04493_ VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__inv_2
X_07825_ _03247_ _04290_ _03273_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__o21a_1
XFILLER_84_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07756_ _03271_ _04224_ VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__or2_1
XFILLER_84_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04968_ _02309_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__clkbuf_1
X_06707_ rf\[28\]\[13\] rf\[29\]\[13\] rf\[30\]\[13\] rf\[31\]\[13\] _03198_ _03193_
+ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__mux4_1
X_09426_ net524 _01398_ VGND VGND VPWR VPWR rf\[20\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04899_ _02273_ VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__clkbuf_1
X_08187__244 clknet_1_0__leaf__04455_ VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__inv_2
X_07687_ _03597_ _04157_ _04159_ _03608_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__a31o_1
X_06638_ rf\[0\]\[13\] VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06569_ _03138_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__clkbuf_1
X_09357_ net455 _01329_ VGND VGND VPWR VPWR rf\[17\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09288_ net386 _01260_ VGND VGND VPWR VPWR rf\[15\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_40 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_10063_ net154 _02035_ VGND VGND VPWR VPWR rf\[31\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04449_ clknet_0__04449_ VGND VGND VPWR VPWR clknet_1_0__leaf__04449_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_11_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08775__799 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__inv_2
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08056__119 clknet_1_1__leaf__04449_ VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__inv_2
XFILLER_78_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05940_ _02117_ _02224_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__nor2_8
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05871_ _02114_ rf\[21\]\[0\] _02744_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__mux2_1
XFILLER_39_658 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07610_ rf\[4\]\[25\] rf\[5\]\[25\] rf\[6\]\[25\] rf\[7\]\[25\] _03582_ _03631_ VGND
+ VGND VPWR VPWR _04087_ sky130_fd_sc_hd__mux4_2
X_04822_ rf\[5\]\[25\] _02064_ _02226_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__mux2_1
X_07541_ _03588_ _04021_ _03693_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__o21a_1
XFILLER_53_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04753_ _02196_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__clkbuf_1
X_04684_ rf\[19\]\[26\] _02062_ _02154_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__mux2_1
X_07472_ _03625_ _03955_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__or2_1
X_09211_ net309 _01183_ VGND VGND VPWR VPWR rf\[13\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_06423_ _03063_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__clkbuf_1
X_09142_ net240 _01114_ VGND VGND VPWR VPWR rf\[11\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_06354_ _03027_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__clkbuf_1
X_05305_ _02483_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__clkbuf_1
X_09073_ net171 _01045_ VGND VGND VPWR VPWR rf\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06285_ _02064_ rf\[14\]\[25\] _02985_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__mux2_1
X_05236_ _02078_ rf\[30\]\[18\] _02434_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__mux2_1
X_05167_ rf\[9\]\[19\] _02076_ _02399_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__mux2_1
XFILLER_89_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09975_ net1073 _01947_ VGND VGND VPWR VPWR rf\[4\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_05098_ _02376_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__clkbuf_1
X_07808_ _03242_ _04274_ VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__or2_1
XFILLER_55_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07739_ _03188_ _04206_ _04208_ _03203_ VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__o211a_1
XFILLER_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09409_ net507 _01381_ VGND VGND VPWR VPWR rf\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_08620__652 clknet_1_1__leaf__04480_ VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__inv_2
XFILLER_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08735__761 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__inv_2
XFILLER_4_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10046_ net137 _02018_ VGND VGND VPWR VPWR rf\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_252 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08480__520 clknet_1_1__leaf__04472_ VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__inv_2
XFILLER_44_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06070_ rf\[18\]\[0\] _02114_ _02847_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__mux2_1
XFILLER_6_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08103__164 clknet_1_1__leaf__04451_ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__inv_2
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05021_ rf\[7\]\[26\] _02062_ _02331_ VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__mux2_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09760_ net858 _01732_ VGND VGND VPWR VPWR rf\[30\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_06972_ _03271_ _03479_ _03273_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__o21a_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05923_ _02804_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__clkbuf_1
XFILLER_100_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09691_ net789 _01663_ VGND VGND VPWR VPWR rf\[28\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05854_ _02768_ VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05785_ _02094_ rf\[22\]\[10\] _02711_ VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__mux2_1
XFILLER_81_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04805_ _02222_ VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__clkbuf_1
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07524_ _04005_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_1
X_08643__674 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__inv_2
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04736_ rf\[19\]\[0\] _02114_ _02153_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__mux2_1
X_07455_ _03933_ _03935_ _03937_ _03939_ _03608_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__a221o_1
X_04667_ rf\[3\]\[1\] _02112_ _02118_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__mux2_1
X_06406_ rf\[12\]\[31\] _02048_ _03054_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__mux2_1
X_07386_ _03588_ _03874_ _03693_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__o21a_1
X_04598_ _02112_ rf\[31\]\[1\] _02051_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__mux2_1
XFILLER_10_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_388 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08758__783 clknet_1_1__leaf__04487_ VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__inv_2
X_09125_ net223 _01097_ VGND VGND VPWR VPWR rf\[29\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_06337_ _02605_ _02949_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__nand2_4
X_06268_ _02982_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__clkbuf_1
X_05219_ _02439_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__clkbuf_1
X_06199_ _02946_ VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__clkbuf_1
X_08039__103 clknet_1_1__leaf__04448_ VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__inv_2
XFILLER_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09958_ net1056 _01930_ VGND VGND VPWR VPWR rf\[5\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09889_ net987 _01861_ VGND VGND VPWR VPWR rf\[10\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_45_403 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08126__186 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__inv_2
X_08930__946 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1058 sky130_fd_sc_hd__inv_2
XFILLER_107_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput60 net60 VGND VGND VPWR VPWR port1_data_o[1] sky130_fd_sc_hd__clkbuf_4
Xoutput71 net71 VGND VGND VPWR VPWR port1_data_o[2] sky130_fd_sc_hd__buf_4
XFILLER_122_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput93 net93 VGND VGND VPWR VPWR port2_data_o[20] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR port2_data_o[10] sky130_fd_sc_hd__buf_2
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08666__696 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__inv_2
XFILLER_63_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10029_ net1127 _02001_ VGND VGND VPWR VPWR rf\[19\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05570_ _02621_ VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__clkbuf_1
X_04521_ _02061_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_63_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07240_ _03579_ _03735_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__or2_1
XFILLER_118_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07171_ rf\[20\]\[3\] rf\[21\]\[3\] rf\[22\]\[3\] rf\[23\]\[3\] _03582_ _03626_ VGND
+ VGND VPWR VPWR _03670_ sky130_fd_sc_hd__mux4_2
X_08790__814 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__inv_2
X_06122_ rf\[17\]\[7\] _02100_ _02882_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__mux2_1
XFILLER_117_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06053_ _02871_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__clkbuf_1
XFILLER_99_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05004_ _02327_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__clkbuf_1
XFILLER_99_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09812_ net910 _01784_ VGND VGND VPWR VPWR rf\[8\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_06955_ _03242_ _03463_ VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__or2_1
X_09743_ net841 _01715_ VGND VGND VPWR VPWR rf\[30\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05906_ rf\[20\]\[16\] _02082_ _02780_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__mux2_1
X_09674_ net772 _01646_ VGND VGND VPWR VPWR rf\[27\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_06886_ _03188_ _03395_ _03397_ _03203_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__o211a_1
X_05837_ _02080_ rf\[21\]\[17\] _02745_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__mux2_1
XFILLER_39_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_575 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05768_ _02724_ VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__clkbuf_1
X_07507_ rf\[8\]\[20\] rf\[9\]\[20\] rf\[10\]\[20\] rf\[11\]\[20\] _03691_ _03696_
+ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__mux4_2
XFILLER_35_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05699_ _02074_ rf\[23\]\[20\] _02677_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__mux2_1
X_04719_ _02177_ VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__clkbuf_1
X_07438_ _03629_ _03923_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__or2_1
X_07369_ _03623_ _03849_ _03858_ _03650_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__o211a_1
X_09108_ net206 _01080_ VGND VGND VPWR VPWR rf\[29\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_452 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08026__91 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__inv_2
XFILLER_77_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_22 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08889__907 clknet_1_1__leaf__04494_ VGND VGND VPWR VPWR net1019 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04462_ clknet_0__04462_ VGND VGND VPWR VPWR clknet_1_1__leaf__04462_
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0__04493_ _04493_ VGND VGND VPWR VPWR clknet_0__04493_ sky130_fd_sc_hd__clkbuf_16
XFILLER_96_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06740_ rf\[12\]\[15\] rf\[13\]\[15\] rf\[14\]\[15\] rf\[15\]\[15\] _03197_ _03192_
+ VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__mux4_2
X_06671_ net2 VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__buf_12
XFILLER_36_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05622_ rf\[24\]\[25\] _02064_ _02642_ VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__mux2_1
X_08410_ clknet_1_0__leaf__04443_ VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__buf_1
X_09390_ net488 _01362_ VGND VGND VPWR VPWR rf\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05553_ _02062_ rf\[25\]\[26\] _02607_ VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__mux2_1
X_05484_ _02060_ rf\[26\]\[27\] _02572_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__mux2_1
X_04504_ net48 net47 net46 VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__and3_4
X_07223_ _03603_ _03719_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__or2_1
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07154_ _03580_ _03651_ _03653_ _03595_ VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__o211a_1
X_06105_ _02898_ VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__clkbuf_1
X_07085_ _03578_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__clkinv_4
XFILLER_121_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06036_ rf\[18\]\[17\] _02080_ _02848_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__mux2_1
X_08534__571 clknet_1_0__leaf__04475_ VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__inv_2
XFILLER_87_689 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07987_ clknet_1_1__leaf__04443_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__buf_1
X_09009__1021 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1133 sky130_fd_sc_hd__inv_2
XFILLER_101_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06938_ _03441_ _03443_ _03445_ _03447_ _03231_ VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__a221o_1
XFILLER_86_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08649__680 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__inv_2
X_09726_ net824 _01698_ VGND VGND VPWR VPWR rf\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_28_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09657_ net755 _01629_ VGND VGND VPWR VPWR rf\[27\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_06869_ _03188_ _03381_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__or2_1
XTAP_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09588_ net686 _01560_ VGND VGND VPWR VPWR rf\[25\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04482_ clknet_0__04482_ VGND VGND VPWR VPWR clknet_1_0__leaf__04482_
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08442__484 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__inv_2
X_08557__593 clknet_1_1__leaf__04476_ VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__inv_2
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04445_ clknet_0__04445_ VGND VGND VPWR VPWR clknet_1_1__leaf__04445_
+ sky130_fd_sc_hd__clkbuf_16
X_07910_ rf\[0\]\[9\] rf\[1\]\[9\] rf\[2\]\[9\] rf\[3\]\[9\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04371_ sky130_fd_sc_hd__mux4_1
Xclkbuf_0__04476_ _04476_ VGND VGND VPWR VPWR clknet_0__04476_ sky130_fd_sc_hd__clkbuf_16
X_07841_ rf\[16\]\[5\] rf\[17\]\[5\] rf\[18\]\[5\] rf\[19\]\[5\] _03197_ _03192_ VGND
+ VGND VPWR VPWR _04306_ sky130_fd_sc_hd__mux4_1
X_08005__72 clknet_1_1__leaf__04445_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__inv_2
X_07772_ _04234_ _04236_ _04238_ _04240_ _03216_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__a221o_4
X_09511_ net609 _01483_ VGND VGND VPWR VPWR rf\[22\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_06723_ _03189_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__buf_12
X_04984_ _02317_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__clkbuf_1
XFILLER_52_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_715 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09442_ net540 _01414_ VGND VGND VPWR VPWR rf\[20\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06654_ rf\[0\]\[5\] VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__clkbuf_1
X_05605_ _02114_ rf\[25\]\[0\] _02606_ VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__mux2_1
XPHY_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06585_ _03146_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__clkbuf_1
X_09373_ net471 _01345_ VGND VGND VPWR VPWR rf\[18\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05536_ _02112_ rf\[26\]\[1\] _02571_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__mux2_1
XFILLER_32_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05467_ _02567_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__clkbuf_1
XFILLER_123_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05398_ _02531_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__clkbuf_1
X_07206_ _03578_ _03703_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__or2_1
X_07137_ _03595_ _03628_ _03633_ _03635_ _03637_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__a32o_1
X_07068_ rf\[20\]\[31\] rf\[21\]\[31\] rf\[22\]\[31\] rf\[23\]\[31\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__mux4_1
XFILLER_114_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06019_ _02854_ VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09709_ net807 _01681_ VGND VGND VPWR VPWR rf\[28\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_567 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04465_ clknet_0__04465_ VGND VGND VPWR VPWR clknet_1_0__leaf__04465_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_31_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06370_ _03035_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__clkbuf_1
X_09008__1020 clknet_1_1__leaf__04500_ VGND VGND VPWR VPWR net1132 sky130_fd_sc_hd__inv_2
X_05321_ _02491_ VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05252_ _02094_ rf\[30\]\[10\] _02434_ VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__mux2_1
XFILLER_115_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05183_ rf\[9\]\[11\] _02092_ _02399_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__mux2_1
XFILLER_103_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09991_ net1089 _01963_ VGND VGND VPWR VPWR rf\[4\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_08873_ clknet_1_1__leaf__04490_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__buf_1
X_08828__849 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__inv_2
X_07824_ rf\[20\]\[4\] rf\[21\]\[4\] rf\[22\]\[4\] rf\[23\]\[4\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _04290_ sky130_fd_sc_hd__mux4_1
Xclkbuf_0__04459_ _04459_ VGND VGND VPWR VPWR clknet_0__04459_ sky130_fd_sc_hd__clkbuf_16
XFILLER_84_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07755_ rf\[20\]\[1\] rf\[21\]\[1\] rf\[22\]\[1\] rf\[23\]\[1\] _03190_ _03263_ VGND
+ VGND VPWR VPWR _04224_ sky130_fd_sc_hd__mux4_1
XFILLER_84_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04967_ rf\[10\]\[20\] _02074_ _02297_ VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__mux2_1
XFILLER_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06706_ _03211_ _03226_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__or2_1
XFILLER_65_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07686_ _03603_ _04158_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__or2_1
X_09425_ net523 _01397_ VGND VGND VPWR VPWR rf\[20\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_06637_ _03172_ VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__clkbuf_1
X_04898_ rf\[6\]\[21\] _02072_ _02262_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__mux2_1
X_08148__207 clknet_1_1__leaf__04453_ VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__inv_2
XFILLER_100_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06568_ _02082_ rf\[29\]\[16\] _03122_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__mux2_1
X_09356_ net454 _01328_ VGND VGND VPWR VPWR rf\[17\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_05519_ _02594_ VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__clkbuf_1
X_09287_ net385 _01259_ VGND VGND VPWR VPWR rf\[15\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_06499_ _03102_ VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__clkbuf_1
X_08573__608 clknet_1_0__leaf__04477_ VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__inv_2
XFILLER_109_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08169_ clknet_1_0__leaf__04446_ VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__buf_1
XFILLER_121_303 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08688__717 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__inv_2
XFILLER_125_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10062_ net153 _02034_ VGND VGND VPWR VPWR rf\[31\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_688 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f__04448_ clknet_0__04448_ VGND VGND VPWR VPWR clknet_1_0__leaf__04448_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_125_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05870_ _02776_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__clkbuf_1
X_08333__381 clknet_1_0__leaf__04464_ VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__inv_2
XFILLER_15_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04821_ _02232_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__clkbuf_1
XFILLER_93_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07540_ rf\[28\]\[21\] rf\[29\]\[21\] rf\[30\]\[21\] rf\[31\]\[21\] _03646_ _03600_
+ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__mux4_2
XFILLER_19_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04752_ rf\[4\]\[26\] _02062_ _02190_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__mux2_1
XFILLER_47_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08448__490 clknet_1_1__leaf__04470_ VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__inv_2
XFILLER_62_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04683_ _02159_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__clkbuf_1
X_07471_ rf\[12\]\[18\] rf\[13\]\[18\] rf\[14\]\[18\] rf\[15\]\[18\] _03599_ _03600_
+ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__mux4_1
X_09210_ net308 _01182_ VGND VGND VPWR VPWR rf\[13\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_06422_ rf\[12\]\[23\] _02068_ _03054_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__mux2_1
X_09141_ net239 _01113_ VGND VGND VPWR VPWR rf\[11\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_06353_ _02066_ rf\[13\]\[24\] _03019_ VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__mux2_1
XFILLER_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05304_ rf\[2\]\[17\] _02080_ _02468_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__mux2_1
X_09072_ net170 _01044_ VGND VGND VPWR VPWR rf\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_30_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06284_ _02991_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__clkbuf_1
X_05235_ _02447_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__clkbuf_1
X_05166_ _02411_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__clkbuf_1
XFILLER_103_358 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09021__25 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__inv_2
X_09974_ net1072 _01946_ VGND VGND VPWR VPWR rf\[4\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_05097_ rf\[8\]\[21\] _02072_ _02365_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__mux2_1
XFILLER_85_710 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07807_ rf\[24\]\[3\] rf\[25\]\[3\] rf\[26\]\[3\] rf\[27\]\[3\] _03251_ _03221_ VGND
+ VGND VPWR VPWR _04274_ sky130_fd_sc_hd__mux4_1
XFILLER_84_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05999_ _02843_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__clkbuf_1
XFILLER_55_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07738_ _03247_ _04207_ VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__or2_1
XFILLER_25_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07669_ _03578_ _04142_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__or2_1
XFILLER_53_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09408_ net506 _01380_ VGND VGND VPWR VPWR rf\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09339_ net437 _01311_ VGND VGND VPWR VPWR rf\[17\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08241__294 clknet_1_1__leaf__04459_ VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__inv_2
XFILLER_107_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10045_ net136 _02017_ VGND VGND VPWR VPWR rf\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05020_ _02336_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06971_ rf\[20\]\[26\] rf\[21\]\[26\] rf\[22\]\[26\] rf\[23\]\[26\] _03267_ _03268_
+ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__mux4_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05922_ rf\[20\]\[8\] _02098_ _02780_ VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__mux2_1
X_09690_ net788 _01662_ VGND VGND VPWR VPWR rf\[28\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05853_ _02096_ rf\[21\]\[9\] _02745_ VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__mux2_1
XFILLER_27_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08992__1005 clknet_1_1__leaf__04499_ VGND VGND VPWR VPWR net1117 sky130_fd_sc_hd__inv_2
XFILLER_82_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04804_ rf\[4\]\[0\] _02114_ _02189_ VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__mux2_1
XFILLER_26_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05784_ _02732_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__clkbuf_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07523_ _03612_ _03995_ _04004_ VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__and3_4
XFILLER_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04735_ _02185_ VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04666_ _02149_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__clkbuf_1
X_07454_ _03699_ _03938_ _03682_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__o21a_1
XFILLER_50_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06405_ _03053_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__buf_12
X_07385_ rf\[28\]\[13\] rf\[29\]\[13\] rf\[30\]\[13\] rf\[31\]\[13\] _03646_ _03600_
+ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__mux4_1
X_04597_ net22 VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__buf_12
X_08719__746 clknet_1_0__leaf__04485_ VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__inv_2
X_09124_ net222 _01096_ VGND VGND VPWR VPWR rf\[29\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_06336_ _03017_ VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__clkbuf_1
X_06267_ _02112_ rf\[15\]\[1\] _02950_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__mux2_1
X_05218_ _02060_ rf\[30\]\[27\] _02434_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__mux2_1
X_06198_ rf\[16\]\[2\] _02110_ _02915_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__mux2_1
XFILLER_104_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05149_ rf\[9\]\[28\] _02058_ _02399_ VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__mux2_1
XFILLER_106_32 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_710 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09957_ net1055 _01929_ VGND VGND VPWR VPWR rf\[5\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09888_ net986 _01860_ VGND VGND VPWR VPWR rf\[10\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08464__505 clknet_1_0__leaf__04471_ VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__inv_2
XFILLER_45_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08579__614 clknet_1_1__leaf__04477_ VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__inv_2
XFILLER_13_356 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput61 net61 VGND VGND VPWR VPWR port1_data_o[20] sky130_fd_sc_hd__buf_2
Xoutput50 net50 VGND VGND VPWR VPWR port1_data_o[10] sky130_fd_sc_hd__buf_2
XFILLER_49_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput72 net72 VGND VGND VPWR VPWR port1_data_o[30] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR port2_data_o[21] sky130_fd_sc_hd__buf_2
Xoutput83 net83 VGND VGND VPWR VPWR port2_data_o[11] sky130_fd_sc_hd__buf_2
X_10028_ net1126 _02000_ VGND VGND VPWR VPWR rf\[19\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08627__659 clknet_1_0__leaf__04480_ VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__inv_2
XFILLER_91_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04520_ _02060_ rf\[31\]\[27\] _02052_ VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__mux2_1
XFILLER_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07170_ _03654_ _03659_ _03669_ _03650_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__o211a_1
XFILLER_118_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06121_ _02906_ VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__clkbuf_1
X_06052_ rf\[18\]\[9\] _02096_ _02848_ VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__mux2_1
X_05003_ rf\[10\]\[2\] _02110_ _02296_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__mux2_1
XFILLER_98_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08372__418 clknet_1_0__leaf__04466_ VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__inv_2
XFILLER_113_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09811_ net909 _01783_ VGND VGND VPWR VPWR rf\[8\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_626 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09742_ net840 _01714_ VGND VGND VPWR VPWR rf\[30\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_08487__527 clknet_1_0__leaf__04472_ VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__inv_2
X_06954_ rf\[24\]\[25\] rf\[25\]\[25\] rf\[26\]\[25\] rf\[27\]\[25\] _03251_ _03221_
+ VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__mux4_2
XFILLER_100_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05905_ _02795_ VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__clkbuf_1
X_09673_ net771 _01645_ VGND VGND VPWR VPWR rf\[27\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06885_ _03247_ _03396_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__or2_1
X_05836_ _02759_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__clkbuf_1
X_05767_ _02076_ rf\[22\]\[19\] _02711_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__mux2_1
XFILLER_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07506_ _03587_ _03987_ VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__or2_1
X_05698_ _02688_ VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__clkbuf_1
X_04718_ rf\[19\]\[9\] _02096_ _02154_ VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__mux2_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07437_ rf\[16\]\[16\] rf\[17\]\[16\] rf\[18\]\[16\] rf\[19\]\[16\] _03639_ _03631_
+ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__mux4_1
X_04649_ rf\[3\]\[10\] _02094_ _02119_ VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__mux2_1
XFILLER_22_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07368_ _03851_ _03853_ _03855_ _03857_ _03608_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__a221o_1
X_09107_ net205 _01079_ VGND VGND VPWR VPWR rf\[29\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_06319_ _02098_ rf\[14\]\[8\] _02985_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__mux2_1
X_07299_ rf\[4\]\[9\] rf\[5\]\[9\] rf\[6\]\[9\] rf\[7\]\[9\] _03582_ _03626_ VGND
+ VGND VPWR VPWR _03792_ sky130_fd_sc_hd__mux4_2
XFILLER_104_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_34 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08132__191 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__inv_2
XFILLER_45_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08991__1004 clknet_1_1__leaf__04499_ VGND VGND VPWR VPWR net1116 sky130_fd_sc_hd__inv_2
XFILLER_115_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04461_ clknet_0__04461_ VGND VGND VPWR VPWR clknet_1_1__leaf__04461_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_5_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_0__04492_ _04492_ VGND VGND VPWR VPWR clknet_0__04492_ sky130_fd_sc_hd__clkbuf_16
XFILLER_122_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06670_ _03190_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__buf_12
XFILLER_36_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05621_ _02648_ VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__clkbuf_1
XFILLER_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05552_ _02612_ VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__clkbuf_1
X_05483_ _02576_ VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__clkbuf_1
X_04503_ net35 VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__buf_12
X_07222_ rf\[8\]\[5\] rf\[9\]\[5\] rf\[10\]\[5\] rf\[11\]\[5\] _03604_ _03605_ VGND
+ VGND VPWR VPWR _03719_ sky130_fd_sc_hd__mux4_1
XFILLER_118_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07153_ _03598_ _03652_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__or2_1
X_06104_ rf\[17\]\[16\] _02082_ _02882_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__mux2_1
XFILLER_118_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07084_ rf\[0\]\[0\] rf\[1\]\[0\] rf\[2\]\[0\] rf\[3\]\[0\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03586_ sky130_fd_sc_hd__mux4_1
X_06035_ _02862_ VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__clkbuf_1
XFILLER_113_250 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07986_ clk_i VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__buf_1
XFILLER_101_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06937_ _03271_ _03446_ _03265_ VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__o21a_1
XFILLER_28_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09725_ net823 _01697_ VGND VGND VPWR VPWR rf\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_09656_ net754 _01628_ VGND VGND VPWR VPWR rf\[27\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06868_ rf\[24\]\[21\] rf\[25\]\[21\] rf\[26\]\[21\] rf\[27\]\[21\] _03198_ _03193_
+ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__mux4_1
XTAP_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_418 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_705 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05819_ _02062_ rf\[21\]\[26\] _02745_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__mux2_1
X_09587_ net685 _01559_ VGND VGND VPWR VPWR rf\[25\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_1_0__f__04481_ clknet_0__04481_ VGND VGND VPWR VPWR clknet_1_0__leaf__04481_
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06799_ _03188_ _03315_ _03265_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__o21a_1
XFILLER_70_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08355__402 clknet_1_0__leaf__04465_ VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__inv_2
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_67 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08895__912 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1024 sky130_fd_sc_hd__inv_2
XFILLER_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08518__556 clknet_1_0__leaf__04474_ VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__inv_2
XFILLER_102_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_570 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_1__f__04444_ clknet_0__04444_ VGND VGND VPWR VPWR clknet_1_1__leaf__04444_
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0__04475_ _04475_ VGND VGND VPWR VPWR clknet_0__04475_ sky130_fd_sc_hd__clkbuf_16
X_07840_ _04298_ _04300_ _04302_ _04304_ net5 VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__a221o_1
XFILLER_110_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08982__995 clknet_1_0__leaf__04499_ VGND VGND VPWR VPWR net1107 sky130_fd_sc_hd__inv_2
X_07771_ _03188_ _04239_ _03265_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__o21a_1
X_09510_ net608 _01482_ VGND VGND VPWR VPWR rf\[22\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_04983_ rf\[10\]\[12\] _02090_ _02297_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__mux2_1
XFILLER_37_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06722_ _03187_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__buf_6
X_09441_ net539 _01413_ VGND VGND VPWR VPWR rf\[20\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06653_ _03180_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05604_ _02638_ VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__clkbuf_1
X_06584_ _02098_ rf\[29\]\[8\] _03122_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__mux2_1
X_09372_ net470 _01344_ VGND VGND VPWR VPWR rf\[18\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05535_ _02602_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__clkbuf_1
X_08263__315 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__inv_2
XFILLER_20_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05466_ _02108_ rf\[27\]\[3\] _02537_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__mux2_1
XFILLER_118_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08378__424 clknet_1_1__leaf__04466_ VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__inv_2
X_07205_ rf\[16\]\[4\] rf\[17\]\[4\] rf\[18\]\[4\] rf\[19\]\[4\] _03589_ _03584_ VGND
+ VGND VPWR VPWR _03703_ sky130_fd_sc_hd__mux4_1
X_05397_ _02106_ rf\[28\]\[4\] _02502_ VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__mux2_1
XFILLER_20_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_9 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07136_ _03588_ _03636_ _03597_ VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__o21a_1
X_07067_ _03242_ _03569_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__or2_1
X_06018_ rf\[18\]\[26\] _02062_ _02848_ VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__mux2_1
XFILLER_99_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_10 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09708_ net806 _01680_ VGND VGND VPWR VPWR rf\[28\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_07969_ _03247_ _04426_ VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__or2_1
XFILLER_28_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08011__76 clknet_1_1__leaf__04447_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__inv_2
X_08805__828 clknet_1_1__leaf__04489_ VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__inv_2
XFILLER_28_576 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09639_ net737 _01611_ VGND VGND VPWR VPWR rf\[26\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_08990__1003 clknet_1_1__leaf__04499_ VGND VGND VPWR VPWR net1115 sky130_fd_sc_hd__inv_2
XFILLER_83_693 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08426__469 clknet_1_0__leaf__04469_ VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__inv_2
Xclkbuf_1_0__f__04464_ clknet_0__04464_ VGND VGND VPWR VPWR clknet_1_0__leaf__04464_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_30_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_579 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_476 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09027__31 clknet_1_1__leaf__04501_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__inv_2
X_09042__45 clknet_1_0__leaf__04502_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__inv_2
XFILLER_3_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07994__61 clknet_1_0__leaf__04445_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__inv_2
XFILLER_3_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08171__228 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__inv_2
XFILLER_93_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_660 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08286__337 clknet_1_0__leaf__04461_ VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__inv_2
XFILLER_34_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05320_ rf\[2\]\[9\] _02096_ _02468_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__mux2_1
XFILLER_9_75 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05251_ _02455_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__clkbuf_1
X_05182_ _02419_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__clkbuf_1
X_09990_ net1088 _01962_ VGND VGND VPWR VPWR rf\[4\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07823_ _03261_ _04288_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__or2_1
Xclkbuf_0__04458_ _04458_ VGND VGND VPWR VPWR clknet_0__04458_ sky130_fd_sc_hd__clkbuf_16
XFILLER_69_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07754_ _04209_ _04214_ _04223_ _03258_ VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__o211a_2
X_04966_ _02308_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__clkbuf_1
X_06705_ rf\[24\]\[13\] rf\[25\]\[13\] rf\[26\]\[13\] rf\[27\]\[13\] _03212_ _03213_
+ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__mux4_1
X_07685_ rf\[8\]\[29\] rf\[9\]\[29\] rf\[10\]\[29\] rf\[11\]\[29\] _03604_ _03613_
+ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__mux4_1
X_09424_ net522 _01396_ VGND VGND VPWR VPWR rf\[20\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_06636_ rf\[0\]\[14\] VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__clkbuf_1
X_04897_ _02272_ VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__clkbuf_1
X_06567_ _03137_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__clkbuf_1
X_09355_ net453 _01327_ VGND VGND VPWR VPWR rf\[17\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05518_ _02094_ rf\[26\]\[10\] _02572_ VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__mux2_1
X_06498_ rf\[11\]\[18\] net20 _03088_ VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__mux2_1
X_09286_ net384 _01258_ VGND VGND VPWR VPWR rf\[15\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_05449_ _02558_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_87 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07119_ _03588_ _03620_ _03597_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__o21a_1
X_08850__870 clknet_1_0__leaf__04492_ VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__inv_2
XFILLER_121_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10061_ net152 _02033_ VGND VGND VPWR VPWR rf\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_1_0__f__04447_ clknet_0__04447_ VGND VGND VPWR VPWR clknet_1_0__leaf__04447_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_8_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04820_ rf\[5\]\[26\] _02062_ _02226_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__mux2_1
XFILLER_93_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04751_ _02195_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07470_ _03580_ _03951_ _03953_ _03595_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__o211a_1
X_04682_ rf\[19\]\[27\] _02060_ _02154_ VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__mux2_1
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06421_ _03062_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__clkbuf_1
X_09140_ net238 _01112_ VGND VGND VPWR VPWR rf\[11\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_06352_ _03026_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__clkbuf_1
X_05303_ _02482_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__clkbuf_1
X_09071_ net169 _01043_ VGND VGND VPWR VPWR rf\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_30_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06283_ _02062_ rf\[14\]\[26\] _02985_ VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__mux2_1
X_08834__854 clknet_1_1__leaf__04492_ VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__inv_2
X_05234_ _02076_ rf\[30\]\[19\] _02434_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__mux2_1
XFILLER_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05165_ rf\[9\]\[20\] _02074_ _02399_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__mux2_1
XFILLER_89_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09973_ net1071 _01945_ VGND VGND VPWR VPWR rf\[4\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_05096_ _02375_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__clkbuf_1
X_08154__212 clknet_1_1__leaf__04454_ VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__inv_2
XFILLER_97_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07806_ _03247_ _04272_ _03273_ VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__o21a_1
X_08269__321 clknet_1_0__leaf__04460_ VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__inv_2
X_05998_ rf\[1\]\[3\] _02108_ _02813_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__mux2_1
X_07737_ rf\[4\]\[0\] rf\[5\]\[0\] rf\[6\]\[0\] rf\[7\]\[0\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _04207_ sky130_fd_sc_hd__mux4_1
XFILLER_53_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04949_ rf\[10\]\[29\] _02056_ _02297_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__mux2_1
X_07668_ rf\[16\]\[28\] rf\[17\]\[28\] rf\[18\]\[28\] rf\[19\]\[28\] _03589_ _03584_
+ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__mux4_1
XFILLER_52_162 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_354 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07599_ _04070_ _04072_ _04074_ _04076_ _03623_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__a221o_1
XFILLER_71_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06619_ _03163_ VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__clkbuf_1
X_09407_ net505 _01379_ VGND VGND VPWR VPWR rf\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_09338_ net436 _01310_ VGND VGND VPWR VPWR rf\[17\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_08694__722 clknet_1_1__leaf__04484_ VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__inv_2
XFILLER_40_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09269_ net367 _01241_ VGND VGND VPWR VPWR rf\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08317__366 clknet_1_1__leaf__04463_ VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__inv_2
X_10044_ net135 _02016_ VGND VGND VPWR VPWR rf\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_36_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08857__876 clknet_1_0__leaf__04493_ VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__inv_2
XFILLER_61_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08062__125 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__inv_2
XFILLER_8_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08177__234 clknet_1_1__leaf__04455_ VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__inv_2
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06970_ _03187_ _03477_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__or2_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05921_ _02803_ VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__clkbuf_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05852_ _02767_ VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__clkbuf_1
XFILLER_66_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04803_ _02221_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__clkbuf_1
X_08571_ clknet_1_0__leaf__04468_ VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__buf_1
X_05783_ _02092_ rf\[22\]\[11\] _02711_ VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__mux2_1
XFILLER_54_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07522_ _03997_ _03999_ _04001_ _04003_ _03622_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__a221o_1
XFILLER_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04734_ rf\[19\]\[1\] _02112_ _02153_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__mux2_1
X_08604__638 clknet_1_0__leaf__04478_ VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__inv_2
X_04665_ rf\[3\]\[2\] _02110_ _02118_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__mux2_1
X_07453_ rf\[4\]\[17\] rf\[5\]\[17\] rf\[6\]\[17\] rf\[7\]\[17\] _03691_ _03626_ VGND
+ VGND VPWR VPWR _03938_ sky130_fd_sc_hd__mux4_2
XFILLER_35_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06404_ _03052_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__clkbuf_4
XFILLER_50_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07384_ _03629_ _03872_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__or2_1
X_09123_ net221 _01095_ VGND VGND VPWR VPWR rf\[29\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_04596_ _02111_ VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__clkbuf_1
XFILLER_50_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08225__279 clknet_1_1__leaf__04458_ VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__inv_2
X_06335_ _02114_ rf\[14\]\[0\] _02984_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__mux2_1
X_06266_ _02981_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__clkbuf_1
X_05217_ _02438_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__clkbuf_1
X_06197_ _02945_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05148_ _02402_ VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__clkbuf_1
XFILLER_106_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05079_ rf\[8\]\[30\] _02054_ _02365_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__mux2_1
X_09956_ net1054 _01928_ VGND VGND VPWR VPWR rf\[5\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_722 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09887_ net985 _01859_ VGND VGND VPWR VPWR rf\[10\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_596 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08085__147 clknet_1_1__leaf__04450_ VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__inv_2
XFILLER_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput51 net51 VGND VGND VPWR VPWR port1_data_o[11] sky130_fd_sc_hd__buf_2
Xoutput73 net73 VGND VGND VPWR VPWR port1_data_o[31] sky130_fd_sc_hd__buf_2
Xoutput62 net62 VGND VGND VPWR VPWR port1_data_o[21] sky130_fd_sc_hd__buf_2
Xoutput84 net84 VGND VGND VPWR VPWR port2_data_o[12] sky130_fd_sc_hd__buf_2
Xoutput95 net95 VGND VGND VPWR VPWR port2_data_o[22] sky130_fd_sc_hd__clkbuf_4
X_10027_ net1125 _01999_ VGND VGND VPWR VPWR rf\[19\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09057__5 clknet_1_1__leaf__04444_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__inv_2
XFILLER_17_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06120_ rf\[17\]\[8\] _02098_ _02882_ VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__mux2_1
XFILLER_8_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06051_ _02870_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__clkbuf_1
X_05002_ _02326_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__clkbuf_1
XFILLER_125_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09810_ net908 _01782_ VGND VGND VPWR VPWR rf\[8\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_101_638 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06953_ _03247_ _03461_ _03273_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__o21a_1
X_09741_ net839 _01713_ VGND VGND VPWR VPWR rf\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_05904_ rf\[20\]\[17\] _02080_ _02780_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__mux2_1
XFILLER_100_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09672_ net770 _01644_ VGND VGND VPWR VPWR rf\[27\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_06884_ rf\[4\]\[22\] rf\[5\]\[22\] rf\[6\]\[22\] rf\[7\]\[22\] _03198_ _03199_ VGND
+ VGND VPWR VPWR _03396_ sky130_fd_sc_hd__mux4_1
X_05835_ _02078_ rf\[21\]\[18\] _02745_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__mux2_1
XFILLER_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05766_ _02723_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04717_ _02176_ VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__clkbuf_1
X_07505_ rf\[12\]\[20\] rf\[13\]\[20\] rf\[14\]\[20\] rf\[15\]\[20\] _03589_ _03584_
+ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__mux4_2
X_05697_ _02072_ rf\[23\]\[21\] _02677_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__mux2_1
XFILLER_50_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07436_ _03597_ _03919_ _03921_ _03608_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__a31o_2
X_04648_ _02140_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__clkbuf_1
X_04579_ net40 VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__buf_12
X_07367_ _03580_ _03856_ _03693_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__o21a_1
XFILLER_109_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06318_ _03008_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__clkbuf_1
X_09106_ net204 _01078_ VGND VGND VPWR VPWR rf\[29\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_07298_ _03579_ _03790_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__or2_1
X_06249_ _02094_ rf\[15\]\[10\] _02951_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__mux2_1
XFILLER_7_6 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09939_ net1037 _01911_ VGND VGND VPWR VPWR rf\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_544 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_51 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08633__664 clknet_1_0__leaf__04481_ VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__inv_2
Xclkbuf_1_1__f__04460_ clknet_0__04460_ VGND VGND VPWR VPWR clknet_1_1__leaf__04460_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_123_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0__04491_ _04491_ VGND VGND VPWR VPWR clknet_0__04491_ sky130_fd_sc_hd__clkbuf_16
X_08017__82 clknet_1_0__leaf__04447_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__inv_2
XFILLER_110_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08032__96 clknet_1_0__leaf__04448_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__inv_2
X_05620_ rf\[24\]\[26\] _02062_ _02642_ VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__mux2_1
XFILLER_24_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05551_ _02060_ rf\[25\]\[27\] _02607_ VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__mux2_1
X_08068__131 clknet_1_0__leaf__04449_ VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__inv_2
X_05482_ _02058_ rf\[26\]\[28\] _02572_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__mux2_1
X_08270_ clknet_1_0__leaf__04457_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__buf_1
X_07221_ _03598_ _03717_ VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__or2_1
X_09048__51 clknet_1_1__leaf__04502_ VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__inv_2
X_07152_ rf\[4\]\[2\] rf\[5\]\[2\] rf\[6\]\[2\] rf\[7\]\[2\] _03590_ _03591_ VGND
+ VGND VPWR VPWR _03652_ sky130_fd_sc_hd__mux4_1
X_08493__532 clknet_1_1__leaf__04473_ VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__inv_2
X_06103_ _02897_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__clkbuf_1
XFILLER_118_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07083_ _03584_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__buf_12
X_06034_ rf\[18\]\[18\] _02078_ _02848_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__mux2_1
XFILLER_113_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07985_ _04428_ _04433_ _04442_ _03220_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__o211a_1
XFILLER_87_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06936_ rf\[28\]\[24\] rf\[29\]\[24\] rf\[30\]\[24\] rf\[31\]\[24\] _03262_ _03263_
+ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__mux4_1
X_09724_ net822 _01696_ VGND VGND VPWR VPWR rf\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09655_ net753 _01627_ VGND VGND VPWR VPWR rf\[27\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_06867_ _03242_ _03379_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__or2_1
XFILLER_67_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08116__176 clknet_1_0__leaf__04452_ VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__inv_2
X_05818_ _02750_ VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__clkbuf_1
XFILLER_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08920__936 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1048 sky130_fd_sc_hd__inv_2
XFILLER_43_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09586_ net684 _01558_ VGND VGND VPWR VPWR rf\[25\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_1_0__f__04480_ clknet_0__04480_ VGND VGND VPWR VPWR clknet_1_0__leaf__04480_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_82_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06798_ rf\[8\]\[17\] rf\[9\]\[17\] rf\[10\]\[17\] rf\[11\]\[17\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__mux4_1
X_05749_ _02058_ rf\[22\]\[28\] _02711_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__mux2_1
XTAP_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07419_ rf\[20\]\[15\] rf\[21\]\[15\] rf\[22\]\[15\] rf\[23\]\[15\] _03695_ _03696_
+ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__mux4_2
XFILLER_11_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08656__686 clknet_1_1__leaf__04482_ VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__inv_2
XFILLER_105_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08780__804 clknet_1_1__leaf__04488_ VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__inv_2
XFILLER_92_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08403__448 clknet_1_1__leaf__04467_ VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__inv_2
XFILLER_123_582 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f__04443_ clknet_0__04443_ VGND VGND VPWR VPWR clknet_1_1__leaf__04443_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0__04474_ _04474_ VGND VGND VPWR VPWR clknet_0__04474_ sky130_fd_sc_hd__clkbuf_16
XFILLER_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08139__198 clknet_1_0__leaf__04453_ VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__inv_2
XFILLER_110_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_628 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_04982_ _02316_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__clkbuf_1
X_07770_ rf\[8\]\[1\] rf\[9\]\[1\] rf\[10\]\[1\] rf\[11\]\[1\] _03254_ _03208_ VGND
+ VGND VPWR VPWR _04239_ sky130_fd_sc_hd__mux4_1
XFILLER_37_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08943__958 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1070 sky130_fd_sc_hd__inv_2
X_06721_ _03205_ _03238_ _03240_ _03216_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__a31o_2
XFILLER_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09440_ net538 _01412_ VGND VGND VPWR VPWR rf\[20\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06652_ rf\[0\]\[6\] VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_37_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05603_ _02112_ rf\[25\]\[1\] _02606_ VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__mux2_1
X_06583_ _03145_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__clkbuf_1
X_09371_ net469 _01343_ VGND VGND VPWR VPWR rf\[18\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_17_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05534_ _02110_ rf\[26\]\[2\] _02571_ VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__mux2_1
XFILLER_33_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05465_ _02566_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__clkbuf_1
X_07204_ _03690_ _03694_ _03698_ _03701_ _03608_ VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__a221o_1
X_05396_ _02530_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07135_ rf\[28\]\[1\] rf\[29\]\[1\] rf\[30\]\[1\] rf\[31\]\[1\] _03583_ _03585_ VGND
+ VGND VPWR VPWR _03636_ sky130_fd_sc_hd__mux4_1
XFILLER_109_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07066_ rf\[16\]\[31\] rf\[17\]\[31\] rf\[18\]\[31\] rf\[19\]\[31\] _03243_ _03244_
+ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__mux4_1
X_06017_ _02853_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__clkbuf_1
XFILLER_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07968_ rf\[4\]\[12\] rf\[5\]\[12\] rf\[6\]\[12\] rf\[7\]\[12\] _03254_ _03199_ VGND
+ VGND VPWR VPWR _04426_ sky130_fd_sc_hd__mux4_1
XFILLER_47_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_09707_ net805 _01679_ VGND VGND VPWR VPWR rf\[28\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_06919_ _03423_ _03425_ _03427_ _03429_ _03216_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__a221o_1
X_07899_ rf\[16\]\[8\] rf\[17\]\[8\] rf\[18\]\[8\] rf\[19\]\[8\] _03197_ _03192_ VGND
+ VGND VPWR VPWR _04361_ sky130_fd_sc_hd__mux4_1
XFILLER_74_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09638_ net736 _01610_ VGND VGND VPWR VPWR rf\[26\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_09569_ net667 _01541_ VGND VGND VPWR VPWR rf\[24\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_31_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_1_0__f__04463_ clknet_0__04463_ VGND VGND VPWR VPWR clknet_1_0__leaf__04463_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_109_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08903__920 clknet_1_0__leaf__04495_ VGND VGND VPWR VPWR net1032 sky130_fd_sc_hd__inv_2
XFILLER_74_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05250_ _02092_ rf\[30\]\[11\] _02434_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__mux2_1
XFILLER_9_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08639__670 clknet_1_1__leaf__04481_ VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__inv_2
X_05181_ rf\[9\]\[12\] _02090_ _02399_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__mux2_1
XFILLER_115_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_0__04457_ _04457_ VGND VGND VPWR VPWR clknet_0__04457_ sky130_fd_sc_hd__clkbuf_16
X_07822_ rf\[16\]\[4\] rf\[17\]\[4\] rf\[18\]\[4\] rf\[19\]\[4\] _03190_ _03244_ VGND
+ VGND VPWR VPWR _04288_ sky130_fd_sc_hd__mux4_1
XFILLER_72_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07753_ _04216_ _04218_ _04220_ _04222_ _03231_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__a221o_1
X_04965_ rf\[10\]\[21\] _02072_ _02297_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__mux2_1
XFILLER_49_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06704_ _03196_ _03224_ _03203_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__o21a_1
XFILLER_80_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04896_ rf\[6\]\[22\] _02070_ _02262_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__mux2_1
X_07684_ _03625_ _04156_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__or2_1
X_09423_ net521 _01395_ VGND VGND VPWR VPWR rf\[20\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06635_ _03171_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__clkbuf_1
X_09354_ net452 _01326_ VGND VGND VPWR VPWR rf\[17\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_06566_ _02080_ rf\[29\]\[17\] _03122_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__mux2_1
X_05517_ _02593_ VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__clkbuf_1
XFILLER_100_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06497_ _03101_ VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09285_ net383 _01257_ VGND VGND VPWR VPWR rf\[15\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_05448_ _02090_ rf\[27\]\[12\] _02538_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__mux2_1
XFILLER_119_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05379_ _02088_ rf\[28\]\[13\] _02503_ VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__mux2_1
X_07118_ rf\[28\]\[0\] rf\[29\]\[0\] rf\[30\]\[0\] rf\[31\]\[0\] _03590_ _03585_ VGND
+ VGND VPWR VPWR _03620_ sky130_fd_sc_hd__mux4_1
XFILLER_109_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07049_ rf\[20\]\[30\] rf\[21\]\[30\] rf\[22\]\[30\] rf\[23\]\[30\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__mux4_2
XFILLER_114_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10060_ net151 _02032_ VGND VGND VPWR VPWR rf\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08432__474 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__inv_2
X_08926__942 clknet_1_1__leaf__04496_ VGND VGND VPWR VPWR net1054 sky130_fd_sc_hd__inv_2
XFILLER_48_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_1_0__f__04446_ clknet_0__04446_ VGND VGND VPWR VPWR clknet_1_0__leaf__04446_
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08671__701 clknet_1_0__leaf__04482_ VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__inv_2
XFILLER_109_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08786__810 clknet_1_0__leaf__04488_ VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__inv_2
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08292__342 clknet_1_1__leaf__04462_ VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__inv_2
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04750_ rf\[4\]\[27\] _02060_ _02190_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__mux2_1
X_08409__454 clknet_1_0__leaf__04467_ VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__inv_2
X_04681_ _02158_ VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__clkbuf_1
X_06420_ rf\[12\]\[24\] _02066_ _03054_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__mux2_1
XFILLER_62_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06351_ _02064_ rf\[13\]\[25\] _03019_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__mux2_1
X_09070_ net168 _01042_ VGND VGND VPWR VPWR rf\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_05302_ rf\[2\]\[18\] _02078_ _02468_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__mux2_1
X_06282_ _02990_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__clkbuf_1
X_05233_ _02446_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__clkbuf_1
X_05164_ _02410_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09972_ net1070 _01944_ VGND VGND VPWR VPWR rf\[4\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_05095_ rf\[8\]\[22\] _02070_ _02365_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__mux2_1
X_08455__496 clknet_1_1__leaf__04471_ VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__inv_2
X_08949__964 clknet_1_1__leaf__04497_ VGND VGND VPWR VPWR net1076 sky130_fd_sc_hd__inv_2
XFILLER_97_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07805_ rf\[20\]\[3\] rf\[21\]\[3\] rf\[22\]\[3\] rf\[23\]\[3\] _03248_ _03213_ VGND
+ VGND VPWR VPWR _04272_ sky130_fd_sc_hd__mux4_1
X_05997_ _02842_ VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07736_ rf\[0\]\[0\] rf\[1\]\[0\] rf\[2\]\[0\] rf\[3\]\[0\] _03191_ _03193_ VGND
+ VGND VPWR VPWR _04206_ sky130_fd_sc_hd__mux4_1
X_04948_ _02299_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__clkbuf_1
XFILLER_44_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04879_ _02263_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__clkbuf_1
X_07667_ _04134_ _04136_ _04138_ _04140_ net10 VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__a221o_1
X_07598_ _03588_ _04075_ _03693_ VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__o21a_1
X_09406_ net504 _01378_ VGND VGND VPWR VPWR rf\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_06618_ rf\[0\]\[23\] VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__clkbuf_1
X_09337_ net435 _01309_ VGND VGND VPWR VPWR rf\[17\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_06549_ _03128_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__clkbuf_1
X_09268_ net366 _01240_ VGND VGND VPWR VPWR rf\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09199_ net297 _01171_ VGND VGND VPWR VPWR rf\[13\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_08202__258 clknet_1_0__leaf__04456_ VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__inv_2
XFILLER_4_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10043_ net134 _02015_ VGND VGND VPWR VPWR rf\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_403 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08742__768 clknet_1_0__leaf__04486_ VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__inv_2
XFILLER_44_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08818__839 clknet_1_0__leaf__04491_ VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__inv_2
XFILLER_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05920_ rf\[20\]\[9\] _02096_ _02780_ VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__mux2_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05851_ _02094_ rf\[21\]\[10\] _02745_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__mux2_1
XFILLER_39_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04802_ rf\[4\]\[1\] _02112_ _02189_ VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__mux2_1
X_05782_ _02731_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__clkbuf_1
X_07521_ _03699_ _04002_ _03693_ VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__o21a_1
XFILLER_81_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04733_ _02184_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__clkbuf_1
XFILLER_62_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04664_ _02148_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_34_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_07452_ _03579_ _03936_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__or2_1
X_08678__707 clknet_1_0__leaf__04483_ VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__inv_2
X_07383_ rf\[24\]\[13\] rf\[25\]\[13\] rf\[26\]\[13\] rf\[27\]\[13\] _03630_ _03613_
+ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__mux4_1
X_06403_ _02501_ _02949_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__and2_1
X_09122_ net220 _01094_ VGND VGND VPWR VPWR rf\[29\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_04595_ _02110_ rf\[31\]\[2\] _02051_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__mux2_1
X_06334_ _03016_ VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06265_ _02110_ rf\[15\]\[2\] _02950_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__mux2_1
X_05216_ _02058_ rf\[30\]\[28\] _02434_ VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__mux2_1
X_06196_ rf\[16\]\[3\] _02108_ _02915_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__mux2_1
XFILLER_116_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_614 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05147_ rf\[9\]\[29\] _02056_ _02399_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__mux2_1
XFILLER_104_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_05078_ _02366_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__clkbuf_1
X_09955_ net1053 _01927_ VGND VGND VPWR VPWR rf\[5\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09886_ net984 _01858_ VGND VGND VPWR VPWR rf\[10\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07719_ rf\[0\]\[31\] rf\[1\]\[31\] rf\[2\]\[31\] rf\[3\]\[31\] _03639_ _03631_ VGND
+ VGND VPWR VPWR _04190_ sky130_fd_sc_hd__mux4_1
XFILLER_26_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08702__730 clknet_1_0__leaf__04484_ VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__inv_2
XFILLER_80_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput52 net52 VGND VGND VPWR VPWR port1_data_o[12] sky130_fd_sc_hd__buf_2
X_08438__480 clknet_1_0__leaf__04470_ VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__inv_2
Xoutput63 net63 VGND VGND VPWR VPWR port1_data_o[22] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR port1_data_o[3] sky130_fd_sc_hd__buf_2
Xoutput85 net85 VGND VGND VPWR VPWR port2_data_o[13] sky130_fd_sc_hd__buf_2
XFILLER_1_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput96 net96 VGND VGND VPWR VPWR port2_data_o[23] sky130_fd_sc_hd__buf_2
XFILLER_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10026_ net1124 _01998_ VGND VGND VPWR VPWR rf\[19\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_36_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06050_ rf\[18\]\[10\] _02094_ _02848_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__mux2_1
X_05001_ rf\[10\]\[3\] _02108_ _02296_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__mux2_1
XFILLER_98_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06952_ rf\[20\]\[25\] rf\[21\]\[25\] rf\[22\]\[25\] rf\[23\]\[25\] _03248_ _03213_
+ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__mux4_1
X_09740_ net838 _01712_ VGND VGND VPWR VPWR rf\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
.ends
