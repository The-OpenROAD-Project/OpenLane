* NGSPICE file created from core.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkdlybuf4s25_1 abstract view
.subckt sky130_fd_sc_hd__clkdlybuf4s25_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkdlybuf4s50_1 abstract view
.subckt sky130_fd_sc_hd__clkdlybuf4s50_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_4 abstract view
.subckt sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_4 abstract view
.subckt sky130_fd_sc_hd__and4bb_4 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

.subckt core VGND VPWR clk_i dmem_addr_o[0] dmem_addr_o[10] dmem_addr_o[11] dmem_addr_o[12]
+ dmem_addr_o[13] dmem_addr_o[14] dmem_addr_o[15] dmem_addr_o[16] dmem_addr_o[17]
+ dmem_addr_o[18] dmem_addr_o[19] dmem_addr_o[1] dmem_addr_o[20] dmem_addr_o[21] dmem_addr_o[22]
+ dmem_addr_o[23] dmem_addr_o[24] dmem_addr_o[25] dmem_addr_o[26] dmem_addr_o[27]
+ dmem_addr_o[28] dmem_addr_o[29] dmem_addr_o[2] dmem_addr_o[30] dmem_addr_o[31] dmem_addr_o[3]
+ dmem_addr_o[4] dmem_addr_o[5] dmem_addr_o[6] dmem_addr_o[7] dmem_addr_o[8] dmem_addr_o[9]
+ dmem_be_o[0] dmem_be_o[1] dmem_be_o[2] dmem_be_o[3] dmem_gnt_i dmem_rdata_i[0] dmem_rdata_i[10]
+ dmem_rdata_i[11] dmem_rdata_i[12] dmem_rdata_i[13] dmem_rdata_i[14] dmem_rdata_i[15]
+ dmem_rdata_i[16] dmem_rdata_i[17] dmem_rdata_i[18] dmem_rdata_i[19] dmem_rdata_i[1]
+ dmem_rdata_i[20] dmem_rdata_i[21] dmem_rdata_i[22] dmem_rdata_i[23] dmem_rdata_i[24]
+ dmem_rdata_i[25] dmem_rdata_i[26] dmem_rdata_i[27] dmem_rdata_i[28] dmem_rdata_i[29]
+ dmem_rdata_i[2] dmem_rdata_i[30] dmem_rdata_i[31] dmem_rdata_i[3] dmem_rdata_i[4]
+ dmem_rdata_i[5] dmem_rdata_i[6] dmem_rdata_i[7] dmem_rdata_i[8] dmem_rdata_i[9]
+ dmem_req_o dmem_rvalid_i dmem_wdata_o[0] dmem_wdata_o[10] dmem_wdata_o[11] dmem_wdata_o[12]
+ dmem_wdata_o[13] dmem_wdata_o[14] dmem_wdata_o[15] dmem_wdata_o[16] dmem_wdata_o[17]
+ dmem_wdata_o[18] dmem_wdata_o[19] dmem_wdata_o[1] dmem_wdata_o[20] dmem_wdata_o[21]
+ dmem_wdata_o[22] dmem_wdata_o[23] dmem_wdata_o[24] dmem_wdata_o[25] dmem_wdata_o[26]
+ dmem_wdata_o[27] dmem_wdata_o[28] dmem_wdata_o[29] dmem_wdata_o[2] dmem_wdata_o[30]
+ dmem_wdata_o[31] dmem_wdata_o[3] dmem_wdata_o[4] dmem_wdata_o[5] dmem_wdata_o[6]
+ dmem_wdata_o[7] dmem_wdata_o[8] dmem_wdata_o[9] dmem_we_o imem_addr_o[0] imem_addr_o[10]
+ imem_addr_o[11] imem_addr_o[12] imem_addr_o[13] imem_addr_o[14] imem_addr_o[15]
+ imem_addr_o[16] imem_addr_o[17] imem_addr_o[18] imem_addr_o[19] imem_addr_o[1] imem_addr_o[20]
+ imem_addr_o[21] imem_addr_o[22] imem_addr_o[23] imem_addr_o[24] imem_addr_o[25]
+ imem_addr_o[26] imem_addr_o[27] imem_addr_o[28] imem_addr_o[29] imem_addr_o[2] imem_addr_o[30]
+ imem_addr_o[31] imem_addr_o[3] imem_addr_o[4] imem_addr_o[5] imem_addr_o[6] imem_addr_o[7]
+ imem_addr_o[8] imem_addr_o[9] imem_be_o[0] imem_be_o[1] imem_be_o[2] imem_be_o[3]
+ imem_gnt_i imem_rdata_i[0] imem_rdata_i[10] imem_rdata_i[11] imem_rdata_i[12] imem_rdata_i[13]
+ imem_rdata_i[14] imem_rdata_i[15] imem_rdata_i[16] imem_rdata_i[17] imem_rdata_i[18]
+ imem_rdata_i[19] imem_rdata_i[1] imem_rdata_i[20] imem_rdata_i[21] imem_rdata_i[22]
+ imem_rdata_i[23] imem_rdata_i[24] imem_rdata_i[25] imem_rdata_i[26] imem_rdata_i[27]
+ imem_rdata_i[28] imem_rdata_i[29] imem_rdata_i[2] imem_rdata_i[30] imem_rdata_i[31]
+ imem_rdata_i[3] imem_rdata_i[4] imem_rdata_i[5] imem_rdata_i[6] imem_rdata_i[7]
+ imem_rdata_i[8] imem_rdata_i[9] imem_req_o imem_rvalid_i imem_wdata_o[0] imem_wdata_o[10]
+ imem_wdata_o[11] imem_wdata_o[12] imem_wdata_o[13] imem_wdata_o[14] imem_wdata_o[15]
+ imem_wdata_o[16] imem_wdata_o[17] imem_wdata_o[18] imem_wdata_o[19] imem_wdata_o[1]
+ imem_wdata_o[20] imem_wdata_o[21] imem_wdata_o[22] imem_wdata_o[23] imem_wdata_o[24]
+ imem_wdata_o[25] imem_wdata_o[26] imem_wdata_o[27] imem_wdata_o[28] imem_wdata_o[29]
+ imem_wdata_o[2] imem_wdata_o[30] imem_wdata_o[31] imem_wdata_o[3] imem_wdata_o[4]
+ imem_wdata_o[5] imem_wdata_o[6] imem_wdata_o[7] imem_wdata_o[8] imem_wdata_o[9]
+ imem_we_o rf_port1_reg_o[0] rf_port1_reg_o[1] rf_port1_reg_o[2] rf_port1_reg_o[3]
+ rf_port1_reg_o[4] rf_port2_reg_o[0] rf_port2_reg_o[1] rf_port2_reg_o[2] rf_port2_reg_o[3]
+ rf_port2_reg_o[4] rf_rs1_i[0] rf_rs1_i[10] rf_rs1_i[11] rf_rs1_i[12] rf_rs1_i[13]
+ rf_rs1_i[14] rf_rs1_i[15] rf_rs1_i[16] rf_rs1_i[17] rf_rs1_i[18] rf_rs1_i[19] rf_rs1_i[1]
+ rf_rs1_i[20] rf_rs1_i[21] rf_rs1_i[22] rf_rs1_i[23] rf_rs1_i[24] rf_rs1_i[25] rf_rs1_i[26]
+ rf_rs1_i[27] rf_rs1_i[28] rf_rs1_i[29] rf_rs1_i[2] rf_rs1_i[30] rf_rs1_i[31] rf_rs1_i[3]
+ rf_rs1_i[4] rf_rs1_i[5] rf_rs1_i[6] rf_rs1_i[7] rf_rs1_i[8] rf_rs1_i[9] rf_rs2_i[0]
+ rf_rs2_i[10] rf_rs2_i[11] rf_rs2_i[12] rf_rs2_i[13] rf_rs2_i[14] rf_rs2_i[15] rf_rs2_i[16]
+ rf_rs2_i[17] rf_rs2_i[18] rf_rs2_i[19] rf_rs2_i[1] rf_rs2_i[20] rf_rs2_i[21] rf_rs2_i[22]
+ rf_rs2_i[23] rf_rs2_i[24] rf_rs2_i[25] rf_rs2_i[26] rf_rs2_i[27] rf_rs2_i[28] rf_rs2_i[29]
+ rf_rs2_i[2] rf_rs2_i[30] rf_rs2_i[31] rf_rs2_i[3] rf_rs2_i[4] rf_rs2_i[5] rf_rs2_i[6]
+ rf_rs2_i[7] rf_rs2_i[8] rf_rs2_i[9] rf_wr_data_o[0] rf_wr_data_o[10] rf_wr_data_o[11]
+ rf_wr_data_o[12] rf_wr_data_o[13] rf_wr_data_o[14] rf_wr_data_o[15] rf_wr_data_o[16]
+ rf_wr_data_o[17] rf_wr_data_o[18] rf_wr_data_o[19] rf_wr_data_o[1] rf_wr_data_o[20]
+ rf_wr_data_o[21] rf_wr_data_o[22] rf_wr_data_o[23] rf_wr_data_o[24] rf_wr_data_o[25]
+ rf_wr_data_o[26] rf_wr_data_o[27] rf_wr_data_o[28] rf_wr_data_o[29] rf_wr_data_o[2]
+ rf_wr_data_o[30] rf_wr_data_o[31] rf_wr_data_o[3] rf_wr_data_o[4] rf_wr_data_o[5]
+ rf_wr_data_o[6] rf_wr_data_o[7] rf_wr_data_o[8] rf_wr_data_o[9] rf_wr_en_o rf_wr_reg_o[0]
+ rf_wr_reg_o[1] rf_wr_reg_o[2] rf_wr_reg_o[3] rf_wr_reg_o[4] rst_ni
XFILLER_67_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3155_ _0465_ _0551_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__and2_1
XFILLER_82_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3086_ _0507_ _0988_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__and2b_1
XFILLER_82_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_168_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3988_ net7 net25 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__mux2_2
XFILLER_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2939_ i_decode_stage.reg_meta_o\[20\] _0727_ _0386_ _0853_ VGND VGND VPWR VPWR _0854_
+ sky130_fd_sc_hd__a211o_1
XFILLER_22_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4609_ _2232_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_117_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4960_ clknet_leaf_3_clk_i _0140_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_64_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3911_ _0444_ _1774_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__nor2_1
X_4891_ clknet_leaf_14_clk_i _0071_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[129\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_149_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3842_ _0448_ _1716_ _1721_ _1501_ _1416_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__o32a_1
XFILLER_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3773_ _0773_ _1654_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__nand2_1
XFILLER_9_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2724_ _0647_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__or4_1
XFILLER_173_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2655_ _0448_ _0583_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a21o_1
XFILLER_118_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2586_ _2333_ _0519_ _0521_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21oi_4
X_4325_ net222 net225 net226 VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__and3_1
XFILLER_141_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4256_ i_decode_stage.decode_state_o\[71\] i_decode_stage.fetch_state_i\[63\] _1982_
+ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__mux2_1
X_3207_ _1111_ _1113_ _1114_ _1105_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__a31oi_1
XFILLER_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4187_ i_decode_stage.fetch_state_i\[29\] i_decode_stage.decode_state_o\[37\] _1967_
+ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__mux2_1
X_3138_ _0465_ _0464_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__and2_1
XFILLER_83_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3069_ _0495_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__nor2_1
XFILLER_36_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2440_ _0386_ _0388_ _0389_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__o31ai_4
XFILLER_170_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2371_ _2337_ _2338_ _2339_ _2340_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__or4b_1
XFILLER_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5090_ clknet_leaf_18_clk_i i_decode_stage.decode_state_o\[34\] net291 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[65\] sky130_fd_sc_hd__dfrtp_1
X_4110_ _1926_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__buf_12
XFILLER_110_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4041_ _0678_ _0682_ _0864_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__and3_1
XFILLER_65_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4943_ clknet_leaf_17_clk_i _0123_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[139\]
+ sky130_fd_sc_hd__dfrtp_4
X_4874_ clknet_leaf_23_clk_i _0054_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[58\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3825_ _1691_ _1703_ _1705_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__or3_1
XFILLER_20_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3756_ _0825_ _1003_ _0782_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2707_ i_decode_stage.decode_state_o\[124\] _0631_ i_decode_stage.decode_state_o\[147\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a221o_1
XFILLER_134_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3687_ _1477_ _1217_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__or2b_1
XFILLER_160_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2638_ _0343_ _0563_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a21o_1
Xoutput220 net220 VGND VGND VPWR VPWR imem_addr_o[28] sky130_fd_sc_hd__buf_2
Xoutput231 net231 VGND VGND VPWR VPWR imem_addr_o[9] sky130_fd_sc_hd__buf_2
Xoutput242 net242 VGND VGND VPWR VPWR rf_wr_data_o[0] sky130_fd_sc_hd__buf_2
Xoutput253 net253 VGND VGND VPWR VPWR rf_wr_data_o[1] sky130_fd_sc_hd__buf_2
XFILLER_160_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2569_ net250 i_decode_stage.reg_meta_o\[61\] _0457_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__mux2_1
Xoutput275 net275 VGND VGND VPWR VPWR rf_wr_reg_o[0] sky130_fd_sc_hd__buf_2
Xoutput264 net264 VGND VGND VPWR VPWR rf_wr_data_o[2] sky130_fd_sc_hd__buf_2
X_4308_ _2040_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
X_5288_ clknet_leaf_6_clk_i _0287_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_59_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4239_ _1998_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_355 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3610_ _0413_ _0972_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__nor2_1
X_4590_ i_decode_stage.reg_meta_o\[66\] net81 _2207_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__mux2_1
X_3541_ _1332_ _1238_ _1251_ _1087_ _1435_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__a221o_1
XFILLER_155_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3472_ _0345_ _0656_ _1080_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__a21oi_1
XFILLER_127_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_170_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2423_ net242 _0363_ _0369_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__and4_1
X_5211_ clknet_leaf_28_clk_i _0210_ net281 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_5142_ clknet_leaf_4_clk_i net414 net296 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[49\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2354_ i_exec_stage.data_fwd_o\[36\] i_decode_stage.decode_state_o\[127\] VGND VGND
+ VPWR VPWR _0308_ sky130_fd_sc_hd__or2b_1
XFILLER_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5073_ clknet_leaf_29_clk_i i_decode_stage.decode_state_o\[17\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[48\] sky130_fd_sc_hd__dfrtp_1
X_4024_ _0461_ _0786_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__nor2_1
XFILLER_65_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4926_ clknet_leaf_20_clk_i _0106_ net288 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dfrtp_4
X_4857_ clknet_leaf_23_clk_i _0037_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[41\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3808_ _0756_ _0762_ _1670_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__or3_1
XFILLER_20_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4788_ _2316_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3739_ _0345_ _0464_ _0485_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__a21o_1
XFILLER_134_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_161_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_77 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2972_ _0709_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__nor2_2
XFILLER_34_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4711_ net209 i_decode_stage.fetch_state_i\[50\] _1927_ VGND VGND VPWR VPWR _2278_
+ sky130_fd_sc_hd__mux2_1
XTAP_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4642_ _2248_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
XFILLER_163_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4573_ _2214_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
XFILLER_155_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3524_ _0424_ _1419_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__nand2_1
XFILLER_115_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3455_ _1199_ _1352_ _1353_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__or3_1
XFILLER_89_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2406_ i_decode_stage.decode_state_o\[120\] net276 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__xnor2_2
X_3386_ _1122_ _1134_ _0660_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__mux2_1
X_5125_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[28\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[28\] sky130_fd_sc_hd__dfrtp_1
XFILLER_97_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5056_ clknet_leaf_7_clk_i net146 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_57_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4007_ net11 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[19\] sky130_fd_sc_hd__a21o_1
XFILLER_26_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4909_ clknet_leaf_15_clk_i _0089_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[243\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold41 i_exec_stage.exec_state_o\[12\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_76_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold30 i_exec_stage.exec_state_o\[69\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold74 i_exec_stage.exec_state_o\[34\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_76_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold52 i_decode_stage.decode_state_o\[31\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold63 i_exec_stage.exec_state_o\[49\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_152_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_310 VGND VGND VPWR VPWR core_310/HI imem_wdata_o[6] sky130_fd_sc_hd__conb_1
XFILLER_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xcore_332 VGND VGND VPWR VPWR core_332/HI imem_wdata_o[28] sky130_fd_sc_hd__conb_1
Xcore_321 VGND VGND VPWR VPWR core_321/HI imem_wdata_o[17] sky130_fd_sc_hd__conb_1
XFILLER_90_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3240_ _0430_ _0889_ _1145_ _0411_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_3_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3171_ _0343_ _0656_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__a21o_1
XFILLER_140_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2955_ _0867_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__and2b_1
XFILLER_148_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2886_ _2336_ _2341_ net255 VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__and3_1
XFILLER_148_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4625_ _2240_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_163_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4556_ _2205_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
XFILLER_150_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3507_ _0938_ _0954_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__and2b_1
XFILLER_143_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4487_ _2170_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
XFILLER_131_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3438_ _0867_ _0884_ _1270_ _0868_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__o211a_1
XFILLER_106_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3369_ _1199_ _1268_ _1269_ _1270_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__o31a_1
XFILLER_112_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5108_ clknet_leaf_11_clk_i i_mem_slice_stage.pre_data\[11\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_58_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5039_ clknet_leaf_5_clk_i net159 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_72_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_162_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput120 rf_rs2_i[29] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
Xinput131 rst_ni VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_12
XFILLER_1_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_278 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2740_ i_mem_slice_stage.mem_state_o\[46\] i_mem_slice_stage.mem_state_o\[7\] _0453_
+ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__mux2_2
XPHY_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2671_ _0358_ _0597_ _0598_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o31a_2
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4410_ net215 _2112_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__and2_1
XFILLER_132_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4341_ net229 _1840_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__or2_1
X_4272_ _2015_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XFILLER_141_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3223_ _0709_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__buf_8
XFILLER_101_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3154_ _1065_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__inv_1
XFILLER_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3085_ _0994_ _0995_ _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__a21o_1
XFILLER_82_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3987_ net30 net16 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__mux2_1
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2938_ _2336_ _2341_ net247 VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__and3_1
XFILLER_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2869_ _2336_ _2341_ net257 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__and3_1
X_4608_ i_decode_stage.reg_meta_o\[75\] net91 _2207_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__mux2_1
XFILLER_151_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4539_ i_decode_stage.decode_state_o\[127\] net49 _2179_ VGND VGND VPWR VPWR _2197_
+ sky130_fd_sc_hd__mux2_1
XFILLER_104_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_165_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_167_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4890_ clknet_leaf_11_clk_i _0070_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[118\]
+ sky130_fd_sc_hd__dfrtp_1
X_3910_ _0386_ _0826_ _0827_ _0828_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__o31a_1
XFILLER_32_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3841_ _0590_ _1571_ _1720_ _0592_ _0409_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__o2111a_1
X_3772_ _0773_ _1654_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__or2_1
XFILLER_164_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2723_ i_exec_stage.data_fwd_o\[10\] VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__inv_2
XFILLER_157_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2654_ _0418_ _0416_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__nand2_4
XFILLER_145_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2585_ _0487_ _0514_ _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__mux2_1
XFILLER_133_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4324_ net155 _2047_ _2048_ _2049_ _2050_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__o221a_1
XFILLER_141_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4255_ _2006_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
X_3206_ i_exec_stage.alu_out\[1\] i_exec_stage.alu_out\[0\] _1106_ VGND VGND VPWR
+ VPWR _1114_ sky130_fd_sc_hd__nand3_1
X_4186_ _1971_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_3137_ _0345_ _0382_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__a21oi_1
XFILLER_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3068_ _2333_ _0978_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__a21o_1
XTAP_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_3000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2370_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__buf_4
X_4040_ _0578_ _0689_ _0693_ _0444_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__o22a_1
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4942_ clknet_leaf_17_clk_i _0122_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[138\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_17_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4873_ clknet_leaf_20_clk_i _0053_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[57\]
+ sky130_fd_sc_hd__dfrtp_1
X_3824_ _1009_ _1010_ _1676_ _1704_ _1156_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__o311a_1
XFILLER_20_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3755_ _0782_ _1637_ _1158_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__a21o_1
XFILLER_146_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3686_ _1281_ _1208_ _1204_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__a21o_1
X_2706_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__inv_2
XFILLER_173_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2637_ _0465_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__and2_1
Xoutput210 net210 VGND VGND VPWR VPWR imem_addr_o[19] sky130_fd_sc_hd__buf_2
XFILLER_133_359 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput221 net221 VGND VGND VPWR VPWR imem_addr_o[29] sky130_fd_sc_hd__buf_2
Xoutput232 net232 VGND VGND VPWR VPWR rf_port1_reg_o[0] sky130_fd_sc_hd__buf_2
Xoutput243 net243 VGND VGND VPWR VPWR rf_wr_data_o[10] sky130_fd_sc_hd__buf_2
XFILLER_102_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput265 net265 VGND VGND VPWR VPWR rf_wr_data_o[30] sky130_fd_sc_hd__buf_2
Xoutput276 net276 VGND VGND VPWR VPWR rf_wr_reg_o[1] sky130_fd_sc_hd__buf_2
X_5356_ net50 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_1
Xoutput254 net254 VGND VGND VPWR VPWR rf_wr_data_o[20] sky130_fd_sc_hd__buf_2
X_2568_ i_mem_slice_stage.mem_state_o\[88\] _0452_ _0508_ _0455_ VGND VGND VPWR VPWR
+ net250 sky130_fd_sc_hd__a22o_1
XFILLER_160_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4307_ i_decode_stage.decode_state_o\[239\] _2039_ _2012_ VGND VGND VPWR VPWR _2040_
+ sky130_fd_sc_hd__mux2_1
X_2499_ _0384_ net193 _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__o21a_2
X_5287_ clknet_leaf_6_clk_i _0286_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_59_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4238_ i_decode_stage.decode_state_o\[62\] i_decode_stage.fetch_state_i\[54\] _1982_
+ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__mux2_1
XFILLER_68_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4169_ _1962_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_28_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3540_ _1241_ _1326_ _1434_ _1041_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__o22ai_2
XFILLER_128_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3471_ _0590_ _0594_ _1130_ _1368_ _1216_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__a32o_1
X_5210_ clknet_leaf_27_clk_i _0209_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2422_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__buf_2
X_5141_ clknet_leaf_8_clk_i net340 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[48\]
+ sky130_fd_sc_hd__dfrtp_1
X_2353_ i_decode_stage.decode_state_o\[126\] i_exec_stage.data_fwd_o\[35\] VGND VGND
+ VPWR VPWR _0307_ sky130_fd_sc_hd__or2b_1
XFILLER_97_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5072_ clknet_leaf_29_clk_i i_decode_stage.decode_state_o\[16\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[47\] sky130_fd_sc_hd__dfrtp_1
X_4023_ _0461_ _0786_ _0794_ _0481_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__a22o_1
XFILLER_84_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4925_ clknet_leaf_20_clk_i _0105_ net287 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dfrtp_4
X_4856_ clknet_leaf_23_clk_i _0036_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[40\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3807_ _1688_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkinv_2
XFILLER_20_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4787_ i_exec_stage.data_fwd_o\[24\] net145 _1838_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__mux2_1
X_3738_ _1553_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__inv_2
XFILLER_134_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3669_ _0413_ _0981_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__nor2_1
XFILLER_130_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2971_ _0451_ _0693_ _0694_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__o21ai_4
XFILLER_62_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4710_ _2277_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_148_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4641_ i_decode_stage.fetch_state_i\[10\] _2073_ _2234_ VGND VGND VPWR VPWR _2248_
+ sky130_fd_sc_hd__mux2_1
XFILLER_116_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4572_ i_decode_stage.reg_meta_o\[57\] net71 _2207_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__mux2_1
XFILLER_171_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3523_ _0417_ _0640_ _0832_ _0413_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__o221a_1
XFILLER_171_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3454_ _1149_ _0945_ _1351_ _1198_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__a22o_1
X_2405_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__nor3_4
X_3385_ _1074_ _0707_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__nand2_2
XFILLER_112_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5124_ clknet_leaf_11_clk_i i_mem_slice_stage.pre_data\[27\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[27\] sky130_fd_sc_hd__dfrtp_1
XFILLER_97_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5055_ clknet_leaf_10_clk_i net145 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_57_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4006_ net10 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[18\] sky130_fd_sc_hd__a21o_1
XFILLER_26_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4908_ clknet_leaf_15_clk_i _0088_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[242\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_166_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4839_ clknet_leaf_27_clk_i _0019_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_119_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold20 i_exec_stage.exec_state_o\[59\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold31 i_exec_stage.exec_state_o\[50\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_48_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold42 i_exec_stage.exec_state_o\[28\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_76_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold64 i_exec_stage.exec_state_o\[47\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold53 i_exec_stage.exec_state_o\[54\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_152_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold75 i_decode_stage.decode_state_o\[36\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_29_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_311 VGND VGND VPWR VPWR core_311/HI imem_wdata_o[7] sky130_fd_sc_hd__conb_1
Xcore_300 VGND VGND VPWR VPWR core_300/HI imem_be_o[0] sky130_fd_sc_hd__conb_1
XFILLER_29_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_333 VGND VGND VPWR VPWR core_333/HI imem_wdata_o[29] sky130_fd_sc_hd__conb_1
Xcore_322 VGND VGND VPWR VPWR core_322/HI imem_wdata_o[18] sky130_fd_sc_hd__conb_1
XFILLER_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3170_ _0343_ _0949_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__nor2_1
XFILLER_121_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2954_ _0683_ _0866_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__nand2_1
XFILLER_50_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2885_ _0791_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__nor2_1
XFILLER_163_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4624_ net211 i_exec_stage.alu_out\[1\] _2042_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__mux2_1
XFILLER_116_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4555_ i_decode_stage.reg_meta_o\[49\] net94 _2179_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__mux2_1
XFILLER_128_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3506_ _1156_ _1384_ _1385_ _1402_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__a31o_4
XFILLER_143_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_413 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4486_ i_decode_stage.reg_meta_o\[15\] net130 _2012_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__mux2_1
X_3437_ _0876_ _0881_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__nor2_1
XFILLER_106_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3368_ _0677_ _0880_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__nand2_1
XFILLER_100_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5107_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[10\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3299_ _1156_ _1161_ _1166_ _1203_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__a31o_4
XFILLER_58_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5038_ clknet_leaf_7_clk_i net158 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_2739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput110 rf_rs2_i[1] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput121 rf_rs2_i[2] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_1
XFILLER_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2670_ i_exec_stage.data_fwd_o\[14\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0599_
+ sky130_fd_sc_hd__or4_1
XFILLER_172_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4340_ net229 _2059_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__xnor2_1
X_4271_ i_decode_stage.decode_state_o\[132\] net54 _2012_ VGND VGND VPWR VPWR _2015_
+ sky130_fd_sc_hd__mux2_1
XFILLER_87_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3222_ _0448_ _1127_ _0584_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__a21o_1
XFILLER_98_168 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3153_ _1062_ _1064_ _0394_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__mux2_1
X_3084_ _0512_ _0963_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__and2b_1
XFILLER_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3986_ _1807_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__buf_4
XFILLER_11_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2937_ _0850_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__nand2_2
XFILLER_50_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2868_ _0773_ _0782_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nand2_1
X_4607_ _2231_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
X_2799_ _0713_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nor2_1
XFILLER_117_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4538_ _2196_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_132_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4469_ _2161_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
XFILLER_104_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3840_ _0662_ _1644_ _1717_ _1719_ _0707_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__a221o_1
XFILLER_44_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3771_ _0825_ _1003_ _0782_ _1006_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__a31o_1
XFILLER_32_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2722_ _0363_ _0369_ _0374_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__and4_1
XFILLER_146_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_357 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2653_ _0524_ _0573_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__mux2_1
XFILLER_172_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2584_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__clkbuf_16
XFILLER_141_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4323_ net225 _1840_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__or2_1
XFILLER_87_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4254_ i_decode_stage.decode_state_o\[70\] i_decode_stage.fetch_state_i\[62\] _1982_
+ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__mux2_1
X_3205_ i_exec_stage.alu_out\[0\] _1112_ i_exec_stage.alu_out\[1\] VGND VGND VPWR
+ VPWR _1113_ sky130_fd_sc_hd__or3b_1
XFILLER_101_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4185_ i_decode_stage.fetch_state_i\[28\] i_decode_stage.decode_state_o\[36\] _1967_
+ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__mux2_1
X_3136_ _0382_ _1046_ _1047_ _0424_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__o211a_1
XFILLER_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3067_ i_decode_stage.decode_state_o\[59\] _0731_ _0733_ VGND VGND VPWR VPWR _0979_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_82_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3969_ net9 _1815_ _1817_ _1810_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__a22o_1
XFILLER_109_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_56 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_3001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_160_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4941_ clknet_leaf_16_clk_i _0121_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[137\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_80_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4872_ clknet_leaf_22_clk_i _0052_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[56\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3823_ _1010_ _1676_ _1009_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__o21ai_1
XFILLER_32_274 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3754_ _0782_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__nor2_2
XFILLER_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3685_ _0590_ _1571_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__a21o_1
X_2705_ _0358_ _0627_ _0628_ _0629_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__o31a_2
XFILLER_173_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2636_ _0451_ _0566_ _0462_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a2bb2o_4
Xoutput200 net200 VGND VGND VPWR VPWR imem_addr_o[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_145_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput211 net211 VGND VGND VPWR VPWR imem_addr_o[1] sky130_fd_sc_hd__buf_2
Xoutput222 net222 VGND VGND VPWR VPWR imem_addr_o[2] sky130_fd_sc_hd__buf_2
Xoutput233 net233 VGND VGND VPWR VPWR rf_port1_reg_o[1] sky130_fd_sc_hd__buf_2
Xoutput244 net244 VGND VGND VPWR VPWR rf_wr_data_o[11] sky130_fd_sc_hd__buf_2
X_2567_ i_mem_slice_stage.mem_state_o\[56\] i_mem_slice_stage.mem_state_o\[17\] _0453_
+ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux2_2
Xoutput266 net266 VGND VGND VPWR VPWR rf_wr_data_o[31] sky130_fd_sc_hd__clkbuf_4
Xoutput277 net277 VGND VGND VPWR VPWR rf_wr_reg_o[2] sky130_fd_sc_hd__buf_2
X_5355_ net49 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_1
Xoutput255 net255 VGND VGND VPWR VPWR rf_wr_data_o[21] sky130_fd_sc_hd__clkbuf_4
X_4306_ net57 _2031_ _2038_ _2033_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__a31o_1
XFILLER_102_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5286_ clknet_leaf_5_clk_i _0285_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_2498_ i_decode_stage.decode_state_o\[128\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a31o_2
XFILLER_141_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4237_ _1997_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4168_ i_decode_stage.fetch_state_i\[20\] i_decode_stage.decode_state_o\[28\] _1936_
+ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__mux2_1
X_3119_ i_decode_stage.decode_state_o\[71\] _0731_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__nand2_1
X_4099_ _1859_ _1860_ _1853_ _1865_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__or4bb_1
XFILLER_83_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3470_ _0707_ _1120_ _1322_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__o21ai_1
XFILLER_170_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2421_ i_decode_stage.reg_meta_o\[81\] net274 _0371_ _0372_ VGND VGND VPWR VPWR _0373_
+ sky130_fd_sc_hd__and4_1
XFILLER_130_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5140_ clknet_leaf_5_clk_i net395 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[47\]
+ sky130_fd_sc_hd__dfrtp_1
X_2352_ _2336_ _2341_ i_decode_stage.reg_meta_o\[6\] VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a21o_1
XFILLER_123_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5071_ clknet_leaf_28_clk_i i_decode_stage.decode_state_o\[15\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[46\] sky130_fd_sc_hd__dfrtp_1
XFILLER_96_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4022_ _0722_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__clkbuf_16
XFILLER_37_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4924_ clknet_leaf_21_clk_i _0104_ net287 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dfrtp_4
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4855_ clknet_leaf_22_clk_i _0035_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[39\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3806_ _1673_ _1677_ _1687_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__and3_1
X_4786_ _2315_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_165_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3737_ _0791_ _1620_ _1621_ _0429_ i_decode_stage.decode_state_o\[239\] VGND VGND
+ VPWR VPWR _1622_ sky130_fd_sc_hd__o2111a_1
XFILLER_20_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3668_ _1129_ _1555_ _1556_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__a21oi_1
XFILLER_106_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3599_ _1408_ _1489_ _1490_ _1340_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__a22o_1
XFILLER_88_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2619_ net262 i_decode_stage.reg_meta_o\[72\] _0457_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__mux2_1
XFILLER_102_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5269_ clknet_leaf_25_clk_i _0268_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_28_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout290 net131 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_6
XFILLER_93_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_439 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2970_ _0876_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__nand2_1
XFILLER_15_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4640_ _2247_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
XFILLER_163_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4571_ _2213_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3522_ _1198_ _0832_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nand2_1
XFILLER_171_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3453_ _0413_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__nor2_1
XFILLER_171_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2404_ i_decode_stage.reg_meta_o\[81\] _0319_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nand3_4
Xclkbuf_2_0__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_0__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
X_5123_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[26\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[26\] sky130_fd_sc_hd__dfrtp_1
X_3384_ _1281_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__and2_1
XFILLER_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5054_ clknet_leaf_10_clk_i net144 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[29\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4005_ net9 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[17\] sky130_fd_sc_hd__a21o_1
XFILLER_65_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4907_ clknet_leaf_15_clk_i _0087_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[241\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_216 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4838_ clknet_leaf_26_clk_i _0018_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_166_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4769_ i_exec_stage.data_fwd_o\[15\] net136 _1839_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__mux2_1
XFILLER_147_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold21 i_exec_stage.exec_state_o\[30\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold32 i_exec_stage.exec_state_o\[13\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold10 i_exec_stage.exec_state_o\[20\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold65 i_decode_stage.decode_state_o\[6\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_76_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold54 i_exec_stage.exec_state_o\[58\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold43 i_exec_stage.reg_meta_o\[2\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_152_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold76 i_exec_stage.exec_state_o\[57\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__clkdlybuf4s50_1
XFILLER_91_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_301 VGND VGND VPWR VPWR core_301/HI imem_be_o[1] sky130_fd_sc_hd__conb_1
XFILLER_29_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_334 VGND VGND VPWR VPWR core_334/HI imem_wdata_o[30] sky130_fd_sc_hd__conb_1
Xcore_323 VGND VGND VPWR VPWR core_323/HI imem_wdata_o[19] sky130_fd_sc_hd__conb_1
Xcore_312 VGND VGND VPWR VPWR core_312/HI imem_wdata_o[8] sky130_fd_sc_hd__conb_1
XFILLER_44_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2953_ _0683_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nor2_1
XFILLER_34_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2884_ _0797_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__nor2_1
XFILLER_163_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4623_ _2239_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
XFILLER_129_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4554_ _2204_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3505_ _1158_ _1387_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__o21ai_1
XFILLER_171_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4485_ _2169_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
XFILLER_131_425 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3436_ _0912_ _1321_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__o21ai_1
X_3367_ _0417_ _0677_ _1267_ _1198_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__a2bb2o_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5106_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[9\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_58_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3298_ _1158_ _1168_ _1190_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__o211ai_1
X_5037_ clknet_leaf_7_clk_i net157 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_2718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput111 rf_rs2_i[20] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_1
Xinput100 rf_rs2_i[10] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
XFILLER_76_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput122 rf_rs2_i[30] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_169_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4270_ _2014_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
X_3221_ _0707_ _1120_ _1126_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a21bo_1
XFILLER_101_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3152_ _0343_ _0556_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__a21o_1
XFILLER_95_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3083_ _0622_ _0971_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__and2b_1
XFILLER_55_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3985_ net29 _1809_ _1828_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[6\] sky130_fd_sc_hd__a21o_1
XFILLER_50_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2936_ _0617_ _0849_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__or2_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2867_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__clkbuf_2
XFILLER_164_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4606_ i_decode_stage.reg_meta_o\[74\] net90 _2207_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__mux2_1
X_2798_ _0707_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__or2_1
XFILLER_117_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4537_ i_decode_stage.decode_state_o\[126\] net48 _2179_ VGND VGND VPWR VPWR _2196_
+ sky130_fd_sc_hd__mux2_1
XFILLER_171_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4468_ i_decode_stage.reg_meta_o\[6\] net99 _2012_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__mux2_1
XFILLER_131_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3419_ _1317_ _1318_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nor2_1
XFILLER_104_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_299 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4399_ net142 _2042_ _2045_ _2107_ _2108_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a221o_1
XFILLER_133_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_83 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3770_ _1638_ _1639_ _1653_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__o21ai_4
XFILLER_32_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2721_ i_mem_slice_stage.mem_state_o\[80\] _0328_ _0644_ _0330_ VGND VGND VPWR VPWR
+ _0645_ sky130_fd_sc_hd__a22oi_4
XFILLER_9_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2652_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__buf_4
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2583_ _2333_ _0519_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a21o_1
XFILLER_153_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4322_ net222 net225 VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__xor2_1
XFILLER_141_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4253_ _2005_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_141_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3204_ i_decode_stage.decode_state_o\[0\] _1110_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nand2_2
XFILLER_87_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4184_ _1970_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_3135_ i_decode_stage.decode_state_o\[238\] i_decode_stage.decode_state_o\[239\]
+ _0465_ _0427_ _0408_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a221o_1
XFILLER_95_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3066_ i_exec_stage.data_fwd_o\[20\] _0726_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__o21ai_4
XFILLER_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3968_ net32 net18 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__mux2_1
XFILLER_11_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2919_ _0832_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nor2b_2
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3899_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__clkbuf_4
XFILLER_109_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_3002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_160_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_170_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4940_ clknet_leaf_17_clk_i _0120_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[147\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_17_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4871_ clknet_leaf_22_clk_i _0051_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[55\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_33_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3822_ _1692_ _1696_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__or3b_1
XFILLER_32_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3753_ _1492_ _1563_ _1634_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__o31a_1
XFILLER_146_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3684_ _0707_ _1415_ _0448_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__a21o_1
X_2704_ i_exec_stage.data_fwd_o\[12\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0629_
+ sky130_fd_sc_hd__or4_1
XFILLER_161_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2635_ _0346_ i_decode_stage.decode_state_o\[130\] VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__or2b_1
Xoutput201 net201 VGND VGND VPWR VPWR imem_addr_o[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_173_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput223 net223 VGND VGND VPWR VPWR imem_addr_o[30] sky130_fd_sc_hd__clkbuf_4
Xoutput234 net234 VGND VGND VPWR VPWR rf_port1_reg_o[2] sky130_fd_sc_hd__buf_2
X_5354_ net48 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_1
Xoutput212 net212 VGND VGND VPWR VPWR imem_addr_o[20] sky130_fd_sc_hd__clkbuf_4
XFILLER_114_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4305_ net37 _2037_ net39 net61 VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__a31o_1
X_2566_ _0451_ _0505_ _0506_ _0492_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput267 net267 VGND VGND VPWR VPWR rf_wr_data_o[3] sky130_fd_sc_hd__buf_2
Xoutput245 net245 VGND VGND VPWR VPWR rf_wr_data_o[12] sky130_fd_sc_hd__buf_2
Xoutput256 net256 VGND VGND VPWR VPWR rf_wr_data_o[22] sky130_fd_sc_hd__buf_2
XFILLER_102_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5285_ clknet_leaf_6_clk_i _0284_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_2497_ _0338_ i_decode_stage.decode_state_o\[140\] i_decode_stage.decode_state_o\[44\]
+ _0339_ _2333_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__a221o_1
XFILLER_59_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput278 net278 VGND VGND VPWR VPWR rf_wr_reg_o[3] sky130_fd_sc_hd__buf_2
X_4236_ i_decode_stage.decode_state_o\[61\] i_decode_stage.fetch_state_i\[53\] _1982_
+ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__mux2_1
XFILLER_56_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4167_ _1961_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_110_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3118_ i_exec_stage.data_fwd_o\[32\] _0726_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__o21ai_4
XFILLER_67_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4098_ _1864_ _1915_ _1858_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__or3b_1
XFILLER_83_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3049_ i_exec_stage.data_fwd_o\[18\] _0726_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__o21ai_4
XFILLER_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_159_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2420_ i_decode_stage.decode_state_o\[123\] net279 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__or2b_1
XFILLER_170_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2351_ _2337_ _2338_ _2339_ _2340_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__nor4b_4
XFILLER_69_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5070_ clknet_leaf_29_clk_i net396 net280 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[45\]
+ sky130_fd_sc_hd__dfrtp_1
X_4021_ _1838_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__clkbuf_16
XFILLER_29_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_481 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4923_ clknet_leaf_22_clk_i _0103_ net286 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dfrtp_4
XFILLER_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4854_ clknet_leaf_19_clk_i _0034_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[38\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_165_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3805_ _1129_ _1369_ _1678_ _1686_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__a211oi_1
X_4785_ i_exec_stage.data_fwd_o\[23\] net144 _1838_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__mux2_1
XFILLER_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3736_ _1598_ _1599_ _0819_ _0818_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__a211o_1
XFILLER_20_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_173_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3667_ _1041_ _1194_ _0713_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__o21a_1
XFILLER_118_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3598_ _0928_ _0935_ _1364_ _1489_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__and4_1
X_2618_ i_mem_slice_stage.mem_state_o\[99\] _0452_ _0552_ _0455_ VGND VGND VPWR VPWR
+ net262 sky130_fd_sc_hd__a22o_1
XFILLER_142_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2549_ i_decode_stage.decode_state_o\[100\] _0491_ _0347_ VGND VGND VPWR VPWR _0492_
+ sky130_fd_sc_hd__a21oi_4
XFILLER_88_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5268_ clknet_leaf_3_clk_i _0267_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_102_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4219_ _1988_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5199_ clknet_leaf_21_clk_i net345 net286 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dfrtp_4
XFILLER_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_166_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout291 net131 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__buf_12
XFILLER_75_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout280 net281 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_12
XFILLER_47_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4570_ i_decode_stage.reg_meta_o\[56\] net70 _2207_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__mux2_1
XFILLER_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3521_ _1087_ _1218_ _1222_ _1332_ _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__a221o_1
XFILLER_171_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3452_ _0650_ _0919_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__nor2_1
XFILLER_170_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3383_ _1282_ _1284_ _0523_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__mux2_1
XFILLER_131_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2403_ i_decode_stage.decode_state_o\[123\] i_exec_stage.data_fwd_o\[37\] VGND VGND
+ VPWR VPWR _0356_ sky130_fd_sc_hd__xnor2_1
XFILLER_130_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5122_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[25\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[25\] sky130_fd_sc_hd__dfrtp_1
XFILLER_124_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5053_ clknet_leaf_7_clk_i net143 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4004_ net8 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[16\] sky130_fd_sc_hd__a21o_1
XFILLER_26_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4906_ clknet_leaf_15_clk_i _0086_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[240\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_40_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4837_ clknet_leaf_29_clk_i _0017_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_138_228 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4768_ _2306_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
XFILLER_5_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3719_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__inv_2
XFILLER_134_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4699_ net203 i_decode_stage.fetch_state_i\[44\] _1967_ VGND VGND VPWR VPWR _2272_
+ sky130_fd_sc_hd__mux2_1
XFILLER_134_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_147 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold11 i_exec_stage.exec_state_o\[18\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold22 i_exec_stage.exec_state_o\[68\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold33 i_exec_stage.exec_state_o\[14\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold44 i_exec_stage.exec_state_o\[64\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold55 i_exec_stage.exec_state_o\[70\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold77 i_exec_stage.exec_state_o\[17\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_75_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold66 i_exec_stage.exec_state_o\[53\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_84_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_302 VGND VGND VPWR VPWR core_302/HI imem_be_o[2] sky130_fd_sc_hd__conb_1
XFILLER_28_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_335 VGND VGND VPWR VPWR core_335/HI imem_wdata_o[31] sky130_fd_sc_hd__conb_1
Xcore_324 VGND VGND VPWR VPWR core_324/HI imem_wdata_o[20] sky130_fd_sc_hd__conb_1
Xcore_313 VGND VGND VPWR VPWR core_313/HI imem_wdata_o[9] sky130_fd_sc_hd__conb_1
XFILLER_83_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2952_ _2333_ net194 _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a21oi_2
XFILLER_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2883_ _0484_ _0796_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__and2_1
X_4622_ net200 i_exec_stage.alu_out\[0\] _2042_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__mux2_1
XFILLER_163_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4553_ i_decode_stage.reg_meta_o\[48\] net93 _2179_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__mux2_1
XFILLER_143_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3504_ _0448_ _1394_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__o21ba_1
X_4484_ i_decode_stage.reg_meta_o\[14\] net129 _2012_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__mux2_1
XFILLER_171_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3435_ _0448_ _1324_ _1331_ _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__a22o_1
XFILLER_116_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3366_ _0413_ _1267_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__nor2_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5105_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[8\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[8\] sky130_fd_sc_hd__dfrtp_1
X_3297_ _0707_ _0713_ _1194_ _1201_ _1163_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__o32a_1
XFILLER_100_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5036_ clknet_leaf_8_clk_i net156 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput101 rf_rs2_i[11] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
XFILLER_103_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput123 rf_rs2_i[31] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_1
Xinput112 rf_rs2_i[21] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
XFILLER_76_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3220_ _0590_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__nand2_1
XFILLER_98_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3151_ _0343_ _0725_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__nor2_1
XFILLER_95_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_362 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3082_ _0964_ _0965_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__or2_1
XFILLER_63_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3984_ net15 _1815_ _1827_ _1810_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__a22o_1
XFILLER_50_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2935_ _0617_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__nand2_1
XFILLER_31_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2866_ _0779_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__or2_1
XFILLER_148_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4605_ _2230_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XFILLER_163_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2797_ _0525_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__or2_1
XFILLER_132_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4536_ _2195_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
XFILLER_131_201 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4467_ _2160_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
XFILLER_132_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3418_ _0897_ _0904_ _0913_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__and3_1
X_4398_ net212 _1927_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__and2_1
X_3349_ _0582_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__or2_1
XFILLER_98_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_18 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5019_ clknet_leaf_27_clk_i _0199_ net283 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[123\]
+ sky130_fd_sc_hd__dfrtp_2
XTAP_2549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_158_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_166_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2720_ i_mem_slice_stage.mem_state_o\[48\] i_mem_slice_stage.mem_state_o\[9\] _0453_
+ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__mux2_2
XFILLER_80_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2651_ _0384_ net192 _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__o21a_1
XFILLER_8_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2582_ i_decode_stage.decode_state_o\[126\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a31oi_4
XFILLER_172_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4321_ _0722_ _1924_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__nand2_4
XFILLER_114_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4252_ i_decode_stage.decode_state_o\[69\] i_decode_stage.fetch_state_i\[61\] _1982_
+ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__mux2_1
X_3203_ _1109_ _1111_ _1105_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__a21oi_1
XFILLER_101_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4183_ i_decode_stage.fetch_state_i\[27\] i_decode_stage.decode_state_o\[35\] _1967_
+ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__mux2_1
X_3134_ _0345_ _0419_ _0417_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__o21a_1
XFILLER_95_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3065_ i_decode_stage.reg_meta_o\[25\] _0727_ _0386_ _0976_ VGND VGND VPWR VPWR _0977_
+ sky130_fd_sc_hd__a211o_1
XFILLER_35_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3967_ net1 _1809_ _1816_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[0\] sky130_fd_sc_hd__a21o_1
XFILLER_51_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2918_ _0640_ _0831_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__nand2_1
XFILLER_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_164_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3898_ i_decode_stage.decode_state_o\[0\] _0601_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__or2_1
XFILLER_109_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2849_ _0762_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nor2b_2
XFILLER_163_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4519_ i_decode_stage.reg_meta_o\[31\] net116 _2179_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__mux2_1
XFILLER_160_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_3003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_167_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4870_ clknet_leaf_22_clk_i _0050_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[54\]
+ sky130_fd_sc_hd__dfrtp_1
X_3821_ _0707_ _1554_ _1701_ _0713_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__a211o_1
XFILLER_33_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3752_ _0790_ _1635_ _1634_ _1565_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_9_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3683_ _1497_ _1570_ _0660_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__mux2_1
X_2703_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[55\] VGND VGND VPWR VPWR _0628_
+ sky130_fd_sc_hd__o31a_1
XFILLER_145_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2634_ i_exec_stage.data_fwd_o\[27\] _0565_ _0460_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__mux2_2
XFILLER_145_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2565_ i_decode_stage.decode_state_o\[122\] _0493_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
Xoutput224 net224 VGND VGND VPWR VPWR imem_addr_o[31] sky130_fd_sc_hd__buf_2
Xoutput202 net202 VGND VGND VPWR VPWR imem_addr_o[11] sky130_fd_sc_hd__buf_2
Xoutput235 net235 VGND VGND VPWR VPWR rf_port1_reg_o[3] sky130_fd_sc_hd__buf_2
X_5353_ net47 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_1
Xoutput213 net213 VGND VGND VPWR VPWR imem_addr_o[21] sky130_fd_sc_hd__buf_2
XFILLER_142_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4304_ net38 VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__inv_2
XFILLER_99_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput268 net268 VGND VGND VPWR VPWR rf_wr_data_o[4] sky130_fd_sc_hd__buf_2
Xoutput246 net246 VGND VGND VPWR VPWR rf_wr_data_o[13] sky130_fd_sc_hd__buf_2
Xoutput257 net257 VGND VGND VPWR VPWR rf_wr_data_o[23] sky130_fd_sc_hd__clkbuf_4
XFILLER_114_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2496_ _0444_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkinv_2
XFILLER_101_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5284_ clknet_leaf_6_clk_i _0283_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[18\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput279 net279 VGND VGND VPWR VPWR rf_wr_reg_o[4] sky130_fd_sc_hd__buf_2
XFILLER_102_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4235_ _1996_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_4166_ i_decode_stage.fetch_state_i\[19\] i_decode_stage.decode_state_o\[27\] _1936_
+ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__mux2_1
XFILLER_110_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3117_ i_decode_stage.reg_meta_o\[37\] _0727_ _0386_ _1028_ VGND VGND VPWR VPWR _1029_
+ sky130_fd_sc_hd__a211o_1
XFILLER_56_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4097_ _0336_ _0381_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__and2_1
X_3048_ i_decode_stage.reg_meta_o\[23\] _0727_ _0386_ _0959_ VGND VGND VPWR VPWR _0960_
+ sky130_fd_sc_hd__a211o_1
XFILLER_24_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4999_ clknet_leaf_30_clk_i _0179_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[60\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_170_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2350_ i_fwd_unit.mem_stage_i\[0\] i_fwd_unit.mem_stage_i\[39\] i_decode_stage.reg_meta_o\[43\]
+ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__and3_1
XFILLER_96_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4020_ net289 VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__buf_8
XFILLER_77_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4922_ clknet_leaf_21_clk_i _0102_ net287 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dfrtp_4
XFILLER_33_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4853_ clknet_leaf_16_clk_i _0033_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[37\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_60_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3804_ _1144_ _0764_ _1683_ _1204_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__a221o_1
X_4784_ _2314_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3735_ _1598_ _1599_ _0819_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__a21oi_1
XFILLER_118_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3666_ _1392_ _1554_ _0590_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__mux2_1
XFILLER_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2617_ i_mem_slice_stage.mem_state_o\[67\] i_mem_slice_stage.mem_state_o\[28\] _0453_
+ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__mux2_1
XFILLER_115_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3597_ _0852_ _1455_ _1444_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__and3b_1
XFILLER_130_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2548_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and2_2
XFILLER_0_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5267_ clknet_leaf_24_clk_i _0266_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_2479_ i_decode_stage.decode_state_o\[238\] _0408_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__nor2_2
XFILLER_102_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4218_ i_decode_stage.decode_state_o\[52\] i_decode_stage.fetch_state_i\[44\] _1982_
+ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__mux2_1
X_5198_ clknet_leaf_25_clk_i net380 net283 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dfrtp_4
XFILLER_28_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4149_ _1952_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout292 net131 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_8
Xfanout281 net131 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_12
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3520_ _1208_ _1412_ _1415_ _1281_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a22o_1
XFILLER_170_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3451_ _0588_ _1348_ _1349_ _1216_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_171_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3382_ _1206_ _1283_ _0421_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__mux2_1
XFILLER_112_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2402_ _0353_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[122\]
+ _0348_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a221o_4
XFILLER_124_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5121_ clknet_leaf_7_clk_i i_mem_slice_stage.pre_data\[24\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[24\] sky130_fd_sc_hd__dfrtp_1
X_5052_ clknet_leaf_5_clk_i net142 net296 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_227 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4003_ _1836_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__buf_4
XFILLER_93_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_143 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4905_ clknet_leaf_13_clk_i _0085_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[239\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_33_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4836_ clknet_leaf_27_clk_i _0016_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_147_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4767_ i_exec_stage.data_fwd_o\[14\] net135 _1839_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__mux2_1
XFILLER_147_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3718_ _1540_ _1603_ _0523_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux2_1
XFILLER_134_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4698_ _2271_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3649_ _0421_ _1496_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__nor2_1
XFILLER_134_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold23 i_exec_stage.exec_state_o\[38\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold12 i_exec_stage.exec_state_o\[36\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_102_332 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_387 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold56 i_exec_stage.exec_state_o\[66\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold34 i_exec_stage.valid_o VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold45 i_exec_stage.exec_state_o\[46\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_91_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold67 i_exec_stage.exec_state_o\[63\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_28_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_325 VGND VGND VPWR VPWR core_325/HI imem_wdata_o[21] sky130_fd_sc_hd__conb_1
Xcore_314 VGND VGND VPWR VPWR core_314/HI imem_wdata_o[10] sky130_fd_sc_hd__conb_1
XFILLER_83_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_303 VGND VGND VPWR VPWR core_303/HI imem_be_o[3] sky130_fd_sc_hd__conb_1
Xcore_336 VGND VGND VPWR VPWR core_336/HI imem_we_o sky130_fd_sc_hd__conb_1
XFILLER_44_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_157_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2951_ i_decode_stage.decode_state_o\[45\] _0339_ _0751_ i_decode_stage.decode_state_o\[129\]
+ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a22o_1
XFILLER_62_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2882_ _0484_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__nor2_1
X_4621_ i_decode_stage.reg_meta_o\[81\] _1928_ _2019_ _2030_ VGND VGND VPWR VPWR _0200_
+ sky130_fd_sc_hd__a22o_1
XFILLER_30_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4552_ _2203_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
XFILLER_171_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3503_ _0949_ _1395_ _1398_ _0448_ _1399_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__a221o_1
X_4483_ _2168_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
X_3434_ _1060_ _1087_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__a21oi_1
XFILLER_116_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3365_ _0677_ _0880_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__nor2_1
XFILLER_97_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5104_ clknet_leaf_11_clk_i i_mem_slice_stage.pre_data\[7\] net296 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[7\] sky130_fd_sc_hd__dfrtp_1
X_3296_ _1195_ _1196_ _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__a21oi_1
XFILLER_100_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5035_ clknet_leaf_8_clk_i net155 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_73_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4819_ i_decode_stage.valid_i _1840_ _2047_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__o21a_1
XFILLER_119_251 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_147_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput102 rf_rs2_i[12] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XFILLER_103_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput113 rf_rs2_i[22] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
XFILLER_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput124 rf_rs2_i[3] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_1
XFILLER_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_158_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3150_ _0343_ _0545_ _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__o21ai_1
XFILLER_79_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3081_ _0966_ _0975_ _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__or3b_1
XFILLER_94_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3983_ net6 net24 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__mux2_1
X_2934_ _2333_ _0846_ _0847_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__a31o_1
XFILLER_50_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_335 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2865_ _0470_ _0778_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__and2_1
XFILLER_163_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4604_ i_decode_stage.reg_meta_o\[73\] net88 _2207_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__mux2_1
XFILLER_163_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2796_ _0540_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__or2_1
X_4535_ i_decode_stage.decode_state_o\[125\] net47 _2179_ VGND VGND VPWR VPWR _2195_
+ sky130_fd_sc_hd__mux2_1
XFILLER_7_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4466_ net36 i_decode_stage.decode_state_o\[140\] _1967_ VGND VGND VPWR VPWR _2160_
+ sky130_fd_sc_hd__mux2_1
XFILLER_171_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3417_ _0897_ _0904_ _0913_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__a21oi_1
X_4397_ _2105_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__nor2_1
X_3348_ _0525_ _0487_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__o21ai_1
XFILLER_131_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3279_ _0590_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__nand2_1
XFILLER_73_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5018_ clknet_leaf_26_clk_i _0198_ net283 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[122\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_2539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_166_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_347 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2650_ i_decode_stage.decode_state_o\[127\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a31o_1
XFILLER_73_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2581_ _0338_ i_decode_stage.decode_state_o\[138\] i_decode_stage.decode_state_o\[42\]
+ _0339_ _2333_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a221o_1
XFILLER_114_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4320_ _2042_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__clkinv_4
XFILLER_153_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4251_ _2004_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
XFILLER_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_257 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3202_ i_decode_stage.decode_state_o\[0\] _1110_ i_exec_stage.alu_out\[1\] i_exec_stage.alu_out\[0\]
+ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__or4_1
X_4182_ _1969_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_3133_ _1041_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__nor2_1
XFILLER_95_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3064_ _2336_ _2341_ net252 VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__and3_1
XFILLER_63_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3966_ _1810_ _1811_ _1815_ net8 VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__a22o_1
XFILLER_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2917_ _0640_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__nor2_2
XFILLER_50_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3897_ _0336_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__inv_2
XFILLER_12_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2848_ _0568_ _0761_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__nand2_1
XFILLER_164_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2779_ _0363_ _0369_ _0374_ net264 VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__and4_1
XFILLER_117_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4518_ _2186_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4449_ net153 _1924_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__nor2_1
XTAP_3004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_303 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_244 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_366 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3820_ _0662_ _1699_ _1700_ _0590_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__o211a_1
X_3751_ _1608_ _1614_ _0789_ _0797_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__a211o_1
X_2702_ _0363_ _0369_ _0374_ net244 VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__and4_1
XFILLER_146_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3682_ _1569_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__inv_2
XFILLER_145_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2633_ net260 i_decode_stage.reg_meta_o\[70\] _0457_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__mux2_1
XFILLER_126_371 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2564_ i_exec_stage.data_fwd_o\[19\] _0504_ _0460_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__mux2_1
Xoutput225 net225 VGND VGND VPWR VPWR imem_addr_o[3] sky130_fd_sc_hd__buf_2
Xoutput203 net203 VGND VGND VPWR VPWR imem_addr_o[12] sky130_fd_sc_hd__buf_2
X_5352_ net46 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__clkbuf_1
Xoutput214 net214 VGND VGND VPWR VPWR imem_addr_o[22] sky130_fd_sc_hd__clkbuf_4
XFILLER_126_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4303_ i_decode_stage.decode_state_o\[238\] _1840_ _2036_ VGND VGND VPWR VPWR _0084_
+ sky130_fd_sc_hd__o21a_1
XFILLER_114_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput236 net236 VGND VGND VPWR VPWR rf_port1_reg_o[4] sky130_fd_sc_hd__buf_2
Xoutput247 net247 VGND VGND VPWR VPWR rf_wr_data_o[14] sky130_fd_sc_hd__clkbuf_4
Xoutput258 net258 VGND VGND VPWR VPWR rf_wr_data_o[24] sky130_fd_sc_hd__clkbuf_4
X_5283_ clknet_leaf_6_clk_i _0282_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_2495_ _0439_ _0442_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__o21ai_4
Xoutput269 net269 VGND VGND VPWR VPWR rf_wr_data_o[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_101_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4234_ i_decode_stage.decode_state_o\[60\] i_decode_stage.fetch_state_i\[52\] _1982_
+ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__mux2_1
XFILLER_67_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4165_ _1960_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_95_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3116_ _2336_ _2341_ net266 VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__and3_1
XFILLER_56_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4096_ i_decode_stage.decode_state_o\[241\] i_decode_stage.decode_state_o\[242\]
+ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__nor2_1
XFILLER_67_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3047_ _2336_ _2341_ net250 VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__and3_1
XFILLER_24_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4998_ clknet_leaf_30_clk_i _0178_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[59\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_149_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3949_ _0741_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__inv_2
XFILLER_23_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4921_ clknet_leaf_21_clk_i _0101_ net287 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dfrtp_4
X_4852_ clknet_leaf_17_clk_i _0032_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[36\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_60_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3803_ _1198_ _0762_ _0763_ _1199_ _1684_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__a221o_1
XFILLER_33_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4783_ i_exec_stage.data_fwd_o\[22\] net143 _1838_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__mux2_1
XFILLER_159_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3734_ _0791_ _1618_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__xnor2_1
XFILLER_174_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3665_ _1473_ _1553_ _0660_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__mux2_1
XFILLER_146_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_28 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2616_ _0451_ _0549_ _0462_ _0550_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_161_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3596_ _0850_ _0851_ _1455_ _1445_ _1487_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__a41o_1
X_2547_ i_exec_stage.data_fwd_o\[20\] _0489_ _0460_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__mux2_1
X_2478_ _0343_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__or2_2
XFILLER_114_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5266_ clknet_leaf_23_clk_i _0265_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_102_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4217_ _1987_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_96_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5197_ clknet_leaf_23_clk_i net374 net289 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dfrtp_4
XFILLER_56_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4148_ i_decode_stage.fetch_state_i\[10\] i_decode_stage.decode_state_o\[18\] _1936_
+ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__mux2_1
X_4079_ _0530_ _0730_ _0741_ _0554_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__a22o_1
XFILLER_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_169_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_147 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout282 net131 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__buf_12
Xfanout293 net294 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_12
XFILLER_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3450_ _0707_ _0573_ _1322_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__o21ai_1
XFILLER_170_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3381_ _0345_ _0677_ _1093_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a21oi_1
XFILLER_131_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2401_ i_decode_stage.decode_state_o\[120\] i_exec_stage.data_fwd_o\[34\] VGND VGND
+ VPWR VPWR _0354_ sky130_fd_sc_hd__xor2_1
X_5120_ clknet_leaf_10_clk_i i_mem_slice_stage.pre_data\[23\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[23\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5051_ clknet_leaf_6_clk_i net141 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[26\]
+ sky130_fd_sc_hd__dfrtp_1
X_4002_ _1835_ _1813_ _1831_ _1834_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__a31o_1
XFILLER_111_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4904_ clknet_leaf_13_clk_i _0084_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[238\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_80_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4835_ clknet_leaf_28_clk_i _0015_ net281 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_4766_ _2305_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3717_ _1568_ _1602_ _0421_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__mux2_1
XFILLER_174_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4697_ net202 i_decode_stage.fetch_state_i\[43\] _1967_ VGND VGND VPWR VPWR _2271_
+ sky130_fd_sc_hd__mux2_1
X_3648_ _0344_ _0507_ _1057_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__a21o_1
X_3579_ _0344_ _0617_ _0609_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__a21o_1
XFILLER_134_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_344 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold13 i_exec_stage.exec_state_o\[41\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_102_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold35 i_exec_stage.exec_state_o\[22\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_88_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5249_ clknet_leaf_22_clk_i _0248_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[47\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_29_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold46 i_exec_stage.exec_state_o\[43\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold24 i_exec_stage.exec_state_o\[51\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_102_399 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold68 i_exec_stage.exec_state_o\[60\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold57 i_exec_stage.exec_state_o\[42\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_90_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xcore_326 VGND VGND VPWR VPWR core_326/HI imem_wdata_o[22] sky130_fd_sc_hd__conb_1
Xcore_315 VGND VGND VPWR VPWR core_315/HI imem_wdata_o[11] sky130_fd_sc_hd__conb_1
XFILLER_71_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_304 VGND VGND VPWR VPWR core_304/HI imem_wdata_o[0] sky130_fd_sc_hd__conb_1
XFILLER_28_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xcore_337 VGND VGND VPWR VPWR imem_req_o core_337/LO sky130_fd_sc_hd__conb_1
XPHY_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_157_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2950_ _0864_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__inv_2
XFILLER_62_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2881_ _2333_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__a21o_1
XTAP_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4620_ _2238_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_129_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4551_ i_decode_stage.reg_meta_o\[47\] net92 _2179_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__mux2_1
X_3502_ _1199_ _0951_ _0928_ _1144_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__a22o_1
X_4482_ i_decode_stage.reg_meta_o\[13\] net128 _2012_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__mux2_1
XFILLER_171_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3433_ _1074_ _0448_ _1332_ _1086_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__a22o_1
XFILLER_116_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3364_ _1158_ _1265_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__nor2_1
X_5103_ clknet_leaf_7_clk_i i_mem_slice_stage.pre_data\[6\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_106_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3295_ _1149_ _0691_ _1162_ _1198_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__a221o_1
XFILLER_97_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5034_ clknet_leaf_8_clk_i net152 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_100_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4818_ _2331_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4749_ i_exec_stage.data_fwd_o\[5\] net156 _1839_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__mux2_1
XFILLER_162_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput114 rf_rs2_i[23] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
Xinput103 rf_rs2_i[13] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
Xinput125 rf_rs2_i[4] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_1
XFILLER_49_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_98 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_428 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3080_ _0983_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__and2_1
XFILLER_79_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3982_ net28 _1809_ _1826_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[5\] sky130_fd_sc_hd__a21o_1
XFILLER_62_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2933_ i_decode_stage.decode_state_o\[55\] _0339_ _0733_ VGND VGND VPWR VPWR _0848_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_16_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_347 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2864_ _0470_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nor2_2
XFILLER_31_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2795_ _0428_ _0697_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nand2_1
X_4603_ _2229_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_144_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4534_ _2194_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4465_ _2159_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
X_3416_ _0411_ _1294_ _1309_ _1316_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__a211o_4
XFILLER_89_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4396_ net212 _2101_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__nor2_1
X_3347_ _0523_ _0571_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__or2_1
XFILLER_100_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3278_ _1181_ _1182_ _0662_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__mux2_1
X_5017_ clknet_leaf_25_clk_i _0197_ net283 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[121\]
+ sky130_fd_sc_hd__dfrtp_2
XTAP_2518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2580_ _0322_ _0515_ _0517_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a31oi_4
XFILLER_153_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4250_ i_decode_stage.decode_state_o\[68\] i_decode_stage.fetch_state_i\[60\] _1982_
+ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__mux2_1
XFILLER_113_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3201_ _0601_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__inv_2
XFILLER_79_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4181_ i_decode_stage.fetch_state_i\[26\] i_decode_stage.decode_state_o\[34\] _1967_
+ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__mux2_1
XFILLER_68_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3132_ _0660_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__nand2_1
XFILLER_122_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3063_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__clkbuf_2
XFILLER_94_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3965_ _1813_ _1814_ i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__o21a_2
XFILLER_148_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3896_ _0411_ _1759_ _1772_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__a21o_4
X_2916_ _2333_ _0829_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a21o_1
XFILLER_10_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2847_ _0568_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__nor2_2
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2778_ _0344_ _0404_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nand2_1
XFILLER_117_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4517_ i_decode_stage.reg_meta_o\[30\] net115 _2179_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__mux2_1
XFILLER_144_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4448_ net221 _1928_ _2144_ _2148_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a22o_1
XFILLER_132_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4379_ _2091_ _2092_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__nor2_1
XFILLER_100_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_256 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3750_ _0818_ _1598_ _0809_ _0817_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__or4_1
XFILLER_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2701_ i_mem_slice_stage.mem_state_o\[82\] _0452_ _0626_ _0455_ VGND VGND VPWR VPWR
+ net244 sky130_fd_sc_hd__a22o_1
XFILLER_158_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3681_ _1538_ _1568_ _0421_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux2_1
XFILLER_146_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2632_ i_mem_slice_stage.mem_state_o\[97\] _0452_ _0564_ _0455_ VGND VGND VPWR VPWR
+ net260 sky130_fd_sc_hd__a22o_1
XFILLER_161_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2563_ net251 i_decode_stage.reg_meta_o\[62\] _0457_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__mux2_1
Xoutput226 net226 VGND VGND VPWR VPWR imem_addr_o[4] sky130_fd_sc_hd__buf_2
Xoutput204 net204 VGND VGND VPWR VPWR imem_addr_o[13] sky130_fd_sc_hd__buf_2
X_5351_ net44 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_1
Xoutput215 net215 VGND VGND VPWR VPWR imem_addr_o[23] sky130_fd_sc_hd__buf_2
XFILLER_160_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4302_ net39 _2031_ _2033_ _1928_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__a211o_1
X_5282_ clknet_leaf_24_clk_i _0281_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[16\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput237 net237 VGND VGND VPWR VPWR rf_port2_reg_o[0] sky130_fd_sc_hd__clkbuf_4
Xoutput248 net248 VGND VGND VPWR VPWR rf_wr_data_o[15] sky130_fd_sc_hd__buf_2
Xoutput259 net259 VGND VGND VPWR VPWR rf_wr_data_o[25] sky130_fd_sc_hd__buf_2
XFILLER_99_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2494_ i_exec_stage.data_fwd_o\[5\] _0322_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__or2_1
X_4233_ _1995_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_2_3__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_3__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
XFILLER_114_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4164_ i_decode_stage.fetch_state_i\[18\] i_decode_stage.decode_state_o\[26\] _1936_
+ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__mux2_1
X_3115_ _0537_ _1022_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__or2b_1
XFILLER_95_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4095_ _1911_ _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__nor2_1
XFILLER_82_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3046_ _0860_ _0938_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a21oi_2
XFILLER_24_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4997_ clknet_leaf_0_clk_i _0177_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[58\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3948_ _0601_ _1802_ _1800_ _1778_ _1779_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__a221o_1
XFILLER_164_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3879_ _1156_ _1026_ _1745_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__a31o_1
XFILLER_164_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_32 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4920_ clknet_leaf_21_clk_i _0100_ net287 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dfrtp_4
XFILLER_45_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4851_ clknet_leaf_16_clk_i _0031_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[35\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_61_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3802_ _0417_ _0568_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__nor2_1
XFILLER_21_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4782_ _2313_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XFILLER_146_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3733_ _0799_ _1615_ _0797_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__a21oi_1
X_3664_ _1517_ _1552_ _0421_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__mux2_1
XFILLER_146_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2615_ _0346_ i_decode_stage.decode_state_o\[131\] VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__or2b_1
XFILLER_115_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3595_ _0850_ _1448_ _0851_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__a21bo_1
XFILLER_130_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2546_ net252 i_decode_stage.reg_meta_o\[63\] _0457_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__mux2_2
XFILLER_141_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2477_ _0347_ _0381_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and2_1
XFILLER_88_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5265_ clknet_leaf_19_clk_i _0264_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[63\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_87_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5196_ clknet_leaf_26_clk_i net397 net283 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dfrtp_4
X_4216_ i_decode_stage.decode_state_o\[51\] i_decode_stage.fetch_state_i\[43\] _1982_
+ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__mux2_1
XFILLER_56_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4147_ _1951_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_110_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4078_ _0468_ _0776_ _1895_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__o21ai_1
X_3029_ _0843_ _0939_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__a21o_1
XFILLER_52_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout283 net131 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_8
Xfanout294 net296 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_12
XFILLER_19_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2400_ i_decode_stage.decode_state_o\[119\] VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__inv_2
XFILLER_7_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3380_ _1153_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__inv_1
XFILLER_170_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5050_ clknet_leaf_5_clk_i net140 net296 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[25\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_69_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4001_ i_exec_stage.exec_state_o\[2\] VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__inv_2
XFILLER_27_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4903_ clknet_leaf_13_clk_i _0083_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[237\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_80_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4834_ clknet_leaf_27_clk_i _0014_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_147_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4765_ i_exec_stage.data_fwd_o\[13\] net134 _1839_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__mux2_1
X_3716_ _0344_ _0484_ _1052_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__a21o_1
XFILLER_146_220 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4696_ _2270_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3647_ _1457_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__inv_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3578_ _0852_ _1469_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__or2_1
XFILLER_115_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2529_ net255 i_decode_stage.reg_meta_o\[65\] _0457_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__mux2_1
XFILLER_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold14 i_exec_stage.exec_state_o\[52\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_152_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold36 i_exec_stage.exec_state_o\[9\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold47 i_exec_stage.exec_state_o\[10\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold25 i_exec_stage.exec_state_o\[31\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_102_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5248_ clknet_leaf_21_clk_i _0247_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[46\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold58 i_exec_stage.exec_state_o\[15\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_56_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold69 i_exec_stage.exec_state_o\[45\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5179_ clknet_leaf_28_clk_i net390 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[86\]
+ sky130_fd_sc_hd__dfrtp_1
Xcore_327 VGND VGND VPWR VPWR core_327/HI imem_wdata_o[23] sky130_fd_sc_hd__conb_1
Xcore_316 VGND VGND VPWR VPWR core_316/HI imem_wdata_o[12] sky130_fd_sc_hd__conb_1
Xcore_305 VGND VGND VPWR VPWR core_305/HI imem_wdata_o[1] sky130_fd_sc_hd__conb_1
XFILLER_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_64 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2880_ i_decode_stage.decode_state_o\[62\] _0731_ _0733_ VGND VGND VPWR VPWR _0795_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_15_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4550_ _2202_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
X_3501_ _0590_ _0594_ _1180_ _1397_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__a31o_1
X_4481_ _2167_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3432_ _0593_ _0707_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__nor2_1
X_3363_ _0881_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__xor2_1
XFILLER_103_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5102_ clknet_leaf_7_clk_i i_mem_slice_stage.pre_data\[5\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_112_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3294_ _0418_ _0413_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nor2_8
XFILLER_100_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5033_ clknet_leaf_7_clk_i i_exec_stage.alu_out\[1\] net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[8\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4817_ i_exec_stage.data_fwd_o\[39\] i_decode_stage.decode_state_o\[7\] _1838_ VGND
+ VGND VPWR VPWR _2331_ sky130_fd_sc_hd__mux2_1
XFILLER_31_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4748_ _2296_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_134_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4679_ _2262_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput115 rf_rs2_i[24] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_1
Xinput104 rf_rs2_i[14] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
Xinput126 rf_rs2_i[5] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_1
XFILLER_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_157_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3981_ net14 _1815_ _1825_ _1810_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__a22o_1
XFILLER_63_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2932_ i_exec_stage.data_fwd_o\[16\] _0439_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__nand2_1
XFILLER_16_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2863_ _0384_ _0776_ _0777_ _0752_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__o211a_1
XFILLER_31_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2794_ _0448_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__or2_2
X_4602_ i_decode_stage.reg_meta_o\[72\] net87 _2207_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__mux2_1
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4533_ i_decode_stage.decode_state_o\[124\] net46 _2179_ VGND VGND VPWR VPWR _2194_
+ sky130_fd_sc_hd__mux2_1
XFILLER_172_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4464_ net35 i_decode_stage.decode_state_o\[139\] _1967_ VGND VGND VPWR VPWR _2159_
+ sky130_fd_sc_hd__mux2_1
XFILLER_132_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3415_ _1156_ _1310_ _1311_ _1315_ _0448_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__a32o_1
X_4395_ net212 _2101_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__and2_1
X_3346_ _1129_ _1245_ _1248_ _0868_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__a22o_1
XFILLER_97_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3277_ _0570_ _0472_ _0421_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__mux2_1
XFILLER_100_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5016_ clknet_leaf_25_clk_i _0196_ net283 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[120\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3200_ _0601_ i_exec_stage.alu_out\[0\] i_exec_stage.alu_out\[1\] VGND VGND VPWR
+ VPWR _1109_ sky130_fd_sc_hd__or3b_1
X_4180_ _1968_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
X_3131_ _0540_ _1042_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__nor2_1
XFILLER_122_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_357 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3062_ _0972_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__and2b_1
XFILLER_75_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3964_ i_exec_stage.exec_state_o\[0\] i_exec_stage.exec_state_o\[1\] i_exec_stage.exec_state_o\[7\]
+ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__nor3_2
XFILLER_23_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3895_ _1156_ _1036_ _1760_ _1771_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__a31o_1
X_2915_ i_decode_stage.decode_state_o\[52\] _0339_ _0733_ VGND VGND VPWR VPWR _0830_
+ sky130_fd_sc_hd__a21oi_1
X_2846_ _0384_ _0759_ _0760_ _0752_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o211a_1
XFILLER_148_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2777_ _0691_ _0695_ _0465_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__mux2_1
XFILLER_160_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4516_ _2185_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
XFILLER_2_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4447_ _2042_ _2147_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__or2_1
XFILLER_144_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4378_ net206 _2085_ net207 VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__a21oi_1
X_3329_ _0869_ _0884_ _1228_ _1231_ _0411_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__o311a_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_160_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_134 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2700_ i_mem_slice_stage.mem_state_o\[50\] i_mem_slice_stage.mem_state_o\[11\] _0453_
+ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__mux2_2
X_3680_ _0344_ _0500_ _1055_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__a21o_1
XFILLER_118_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2631_ i_mem_slice_stage.mem_state_o\[65\] i_mem_slice_stage.mem_state_o\[26\] _0453_
+ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__mux2_1
XFILLER_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput205 net205 VGND VGND VPWR VPWR imem_addr_o[14] sky130_fd_sc_hd__buf_2
X_5350_ net43 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_1
Xoutput216 net216 VGND VGND VPWR VPWR imem_addr_o[24] sky130_fd_sc_hd__buf_2
X_2562_ i_mem_slice_stage.mem_state_o\[89\] _0452_ _0503_ _0455_ VGND VGND VPWR VPWR
+ net251 sky130_fd_sc_hd__a22o_1
XFILLER_154_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4301_ i_decode_stage.decode_state_o\[237\] _1840_ _2035_ VGND VGND VPWR VPWR _0083_
+ sky130_fd_sc_hd__o21a_1
XFILLER_114_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5281_ clknet_leaf_3_clk_i _0280_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[15\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput227 net227 VGND VGND VPWR VPWR imem_addr_o[5] sky130_fd_sc_hd__clkbuf_4
Xoutput238 net238 VGND VGND VPWR VPWR rf_port2_reg_o[1] sky130_fd_sc_hd__buf_2
Xoutput249 net249 VGND VGND VPWR VPWR rf_wr_data_o[16] sky130_fd_sc_hd__buf_2
XFILLER_141_354 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2493_ i_decode_stage.reg_meta_o\[10\] net268 _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__mux2_1
X_4232_ i_decode_stage.decode_state_o\[59\] i_decode_stage.fetch_state_i\[51\] _1982_
+ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__mux2_1
X_4163_ _1959_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_3114_ _0746_ _1017_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__a21o_1
XFILLER_95_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4094_ _1903_ _1908_ _1910_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__and3_1
XFILLER_68_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3045_ _0852_ _0943_ _0955_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__a211o_1
XFILLER_71_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4996_ clknet_leaf_0_clk_i _0176_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[57\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3947_ _0749_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__inv_2
XFILLER_23_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3878_ _1750_ _1751_ _1752_ _1755_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__or4_1
XFILLER_164_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2829_ _0556_ _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__and2b_1
XFILLER_155_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_171_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_62 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_167_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_31 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_75 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4850_ clknet_leaf_18_clk_i _0030_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[34\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_45_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3801_ _0590_ _1541_ _1681_ _1396_ _1682_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__o221ai_4
XFILLER_159_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4781_ i_exec_stage.data_fwd_o\[21\] net142 _1839_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__mux2_1
XFILLER_159_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3732_ _1600_ _1601_ _1612_ _1617_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__a211o_4
XFILLER_9_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3663_ _0495_ _0507_ _0465_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__mux2_1
XFILLER_146_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2614_ i_exec_stage.data_fwd_o\[28\] _0548_ _0460_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__mux2_1
XFILLER_161_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3594_ _1156_ _1467_ _1468_ _1486_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__a31o_2
X_2545_ i_mem_slice_stage.mem_state_o\[90\] _0452_ _0488_ _0455_ VGND VGND VPWR VPWR
+ net252 sky130_fd_sc_hd__a22o_1
XFILLER_130_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2476_ _0404_ _0417_ _0419_ _0420_ _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__o221a_1
XFILLER_114_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5264_ clknet_leaf_17_clk_i _0263_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_68_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5195_ clknet_leaf_22_clk_i net392 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[102\]
+ sky130_fd_sc_hd__dfrtp_1
X_4215_ _1986_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4146_ i_decode_stage.fetch_state_i\[9\] i_decode_stage.decode_state_o\[17\] _1936_
+ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__mux2_1
XFILLER_95_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4077_ _0535_ _1020_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__nand2_1
XFILLER_71_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3028_ _0603_ _0840_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__and2b_1
XFILLER_169_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4979_ clknet_leaf_25_clk_i _0159_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[126\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_109_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_227 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout295 net296 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_12
Xfanout284 net285 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_12
XFILLER_59_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4000_ net7 _1807_ _1813_ _1831_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[15\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_111_357 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4902_ clknet_leaf_13_clk_i _0082_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[236\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_45_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4833_ clknet_leaf_29_clk_i _0013_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[17\]
+ sky130_fd_sc_hd__dfrtp_1
X_4764_ _2304_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_146_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3715_ _1598_ _1599_ _1156_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__o21a_1
XFILLER_147_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4695_ net201 i_decode_stage.fetch_state_i\[42\] _1967_ VGND VGND VPWR VPWR _2270_
+ sky130_fd_sc_hd__mux2_1
XFILLER_174_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3646_ _0424_ _1535_ _0990_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__a21oi_1
XFILLER_162_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3577_ _0852_ _1469_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__nand2_1
XFILLER_161_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2528_ i_mem_slice_stage.mem_state_o\[92\] _0452_ _0473_ _0455_ VGND VGND VPWR VPWR
+ net255 sky130_fd_sc_hd__a22o_1
XFILLER_114_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5247_ clknet_leaf_21_clk_i _0246_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[45\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_152_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2459_ i_decode_stage.decode_state_o\[238\] i_decode_stage.decode_state_o\[239\]
+ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nor2_2
XFILLER_88_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold15 i_exec_stage.exec_state_o\[39\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold37 i_exec_stage.reg_meta_o\[1\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold26 i_exec_stage.exec_state_o\[61\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_130_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold48 i_exec_stage.exec_state_o\[11\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_69_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold59 i_decode_stage.decode_state_o\[14\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5178_ clknet_leaf_29_clk_i net403 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[85\]
+ sky130_fd_sc_hd__dfrtp_1
X_4129_ net63 net35 net65 net36 VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__or4_1
XFILLER_56_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_317 VGND VGND VPWR VPWR core_317/HI imem_wdata_o[13] sky130_fd_sc_hd__conb_1
Xcore_306 VGND VGND VPWR VPWR core_306/HI imem_wdata_o[2] sky130_fd_sc_hd__conb_1
XFILLER_56_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xcore_328 VGND VGND VPWR VPWR core_328/HI imem_wdata_o[24] sky130_fd_sc_hd__conb_1
XFILLER_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_165_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_105 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3500_ _0589_ _1216_ _1179_ _1313_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__a32o_1
XFILLER_144_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4480_ i_decode_stage.reg_meta_o\[12\] net127 _2012_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__mux2_1
XFILLER_7_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3431_ _1044_ _1326_ _1330_ _1041_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__o22a_1
X_3362_ _0867_ _0884_ _1228_ _0868_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__o31a_1
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5101_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[4\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3293_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__buf_8
XFILLER_85_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5032_ clknet_leaf_8_clk_i i_exec_stage.alu_out\[0\] net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4816_ _1839_ i_decode_stage.decode_state_o\[4\] i_exec_stage.valid _2330_ VGND VGND
+ VPWR VPWR _0303_ sky130_fd_sc_hd__a31o_1
XFILLER_147_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4747_ i_exec_stage.data_fwd_o\[4\] net155 _1839_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__mux2_1
XFILLER_31_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_427 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4678_ i_decode_stage.fetch_state_i\[1\] net211 _2234_ VGND VGND VPWR VPWR _2262_
+ sky130_fd_sc_hd__mux2_1
XFILLER_174_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3629_ _0590_ _1358_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__or2_1
XFILLER_134_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput116 rf_rs2_i[25] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
Xinput105 rf_rs2_i[15] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
Xinput127 rf_rs2_i[6] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_1
XFILLER_49_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_157_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3980_ net5 net22 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__mux2_1
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2931_ _0844_ _0845_ _0439_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__o21bai_1
XFILLER_15_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2862_ i_decode_stage.decode_state_o\[64\] _0731_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nand2_1
XFILLER_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4601_ _2228_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2793_ _0409_ _0592_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__nand2_4
XFILLER_129_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4532_ _2193_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4463_ _2158_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
X_3414_ _1088_ _1312_ _1314_ _0707_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_116_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_171_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4394_ net141 _2042_ _2045_ _2103_ _2104_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__a221o_1
X_3345_ _1199_ _1246_ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__or3_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3276_ _0486_ _0502_ _0421_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__mux2_1
XFILLER_100_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5015_ clknet_leaf_26_clk_i _0195_ net283 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[119\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_2509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_158_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_227 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3130_ _0344_ _0427_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand2_1
XFILLER_68_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3061_ _0622_ _0971_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__nand2_1
XFILLER_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3963_ _1812_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__clkbuf_4
XFILLER_50_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3894_ _0712_ _1766_ _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__o21ai_1
X_2914_ _0386_ _0826_ _0827_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__o31ai_4
XFILLER_31_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2845_ i_decode_stage.decode_state_o\[66\] _0731_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__nand2_1
XFILLER_163_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2776_ _0451_ _0693_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__o21a_1
X_4515_ i_decode_stage.reg_meta_o\[29\] net114 _2179_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__mux2_1
XFILLER_132_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4446_ net221 _2140_ _2146_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__o21a_1
XFILLER_171_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4377_ net206 net207 _2085_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__and3_1
X_3328_ _0884_ _1228_ _0869_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__o21ai_1
XFILLER_113_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3259_ _1162_ _1163_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__or2_1
XFILLER_100_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_169_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_341 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_166 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2630_ _0451_ _0561_ _0462_ _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_40_291 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2561_ i_mem_slice_stage.mem_state_o\[57\] i_mem_slice_stage.mem_state_o\[18\] _0453_
+ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__mux2_1
Xoutput206 net206 VGND VGND VPWR VPWR imem_addr_o[15] sky130_fd_sc_hd__buf_2
Xoutput217 net217 VGND VGND VPWR VPWR imem_addr_o[25] sky130_fd_sc_hd__buf_2
XFILLER_141_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4300_ net38 _2031_ _2033_ _1928_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__a211o_1
X_2492_ _0324_ _0326_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__nor2_1
X_5280_ clknet_leaf_25_clk_i _0279_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput228 net228 VGND VGND VPWR VPWR imem_addr_o[6] sky130_fd_sc_hd__buf_2
Xoutput239 net239 VGND VGND VPWR VPWR rf_port2_reg_o[2] sky130_fd_sc_hd__buf_2
XFILLER_153_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4231_ _1994_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_4_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_366 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4162_ i_decode_stage.fetch_state_i\[17\] i_decode_stage.decode_state_o\[25\] _1936_
+ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__mux2_1
X_3113_ _1023_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nor2_2
X_4093_ _1903_ _1908_ _1910_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__a21oi_1
XFILLER_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3044_ _0617_ _0849_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__and2b_1
XFILLER_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4995_ clknet_leaf_30_clk_i _0175_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[56\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_23_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3946_ _0601_ _1801_ _1800_ _0932_ _1777_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__a221o_1
XFILLER_23_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3877_ _1753_ _1754_ _1024_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__a21oi_1
XFILLER_109_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2828_ _2333_ _0741_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__a21o_1
XFILLER_164_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2759_ i_mem_slice_stage.mem_state_o\[44\] i_mem_slice_stage.mem_state_o\[5\] _0453_
+ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__mux2_1
XFILLER_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4429_ net218 _2125_ _2132_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__o21a_1
XFILLER_171_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_155_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3800_ _0707_ _0660_ _1603_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__or3_1
X_4780_ _2312_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3731_ _0799_ _1615_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__o21a_1
XTAP_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3662_ _1129_ _1188_ _1479_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__a21oi_1
XFILLER_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3593_ _0411_ _1470_ _1471_ _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__a31o_1
X_2613_ net261 i_decode_stage.reg_meta_o\[71\] _0457_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__mux2_1
XFILLER_161_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2544_ i_mem_slice_stage.mem_state_o\[58\] i_mem_slice_stage.mem_state_o\[19\] _0453_
+ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__mux2_1
XFILLER_130_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2475_ _0422_ _0404_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a21o_1
X_5263_ clknet_leaf_17_clk_i _0262_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[61\]
+ sky130_fd_sc_hd__dfrtp_1
X_5194_ clknet_leaf_19_clk_i net367 net288 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[101\]
+ sky130_fd_sc_hd__dfrtp_1
X_4214_ i_decode_stage.decode_state_o\[50\] i_decode_stage.fetch_state_i\[42\] _1982_
+ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__mux2_1
XFILLER_95_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4145_ _1950_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_56_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4076_ _0566_ _0759_ _0768_ _0561_ _1893_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__o221ai_4
X_3027_ _0640_ _0831_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__and2b_1
XFILLER_71_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4978_ clknet_leaf_24_clk_i _0158_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[125\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3929_ _1791_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__inv_2
XFILLER_166_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout296 net297 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_8
XFILLER_101_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout285 net131 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__buf_8
XFILLER_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_128_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4901_ clknet_leaf_15_clk_i _0081_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[235\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_46_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4832_ clknet_leaf_29_clk_i _0012_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_159_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4763_ i_exec_stage.data_fwd_o\[12\] net133 _1839_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__mux2_1
XFILLER_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3714_ _1598_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__nand2_1
X_4694_ _2269_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
XFILLER_119_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_108 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3645_ _0417_ _0507_ _0989_ _0413_ _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__o221a_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3576_ _1460_ _1446_ _1448_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__a21oi_1
XFILLER_170_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2527_ i_mem_slice_stage.mem_state_o\[60\] i_mem_slice_stage.mem_state_o\[21\] _0453_
+ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__mux2_2
XFILLER_130_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2458_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[237\]
+ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__or2_1
XFILLER_115_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5246_ clknet_leaf_21_clk_i _0245_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[44\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold38 i_exec_stage.exec_state_o\[24\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold27 i_exec_stage.exec_state_o\[65\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_29_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold16 i_decode_stage.decode_state_o\[10\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkdlybuf4s25_1
X_2389_ _2333_ _0336_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__a21bo_1
XFILLER_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold49 i_exec_stage.exec_state_o\[48\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5177_ clknet_leaf_28_clk_i net351 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[84\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_83_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4128_ i_decode_stage.decode_state_o\[6\] _1928_ _1932_ _1941_ _1940_ VGND VGND VPWR
+ VPWR _0004_ sky130_fd_sc_hd__a221o_1
XFILLER_56_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_318 VGND VGND VPWR VPWR core_318/HI imem_wdata_o[14] sky130_fd_sc_hd__conb_1
X_4059_ _0600_ _0838_ _0855_ _0606_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__o22a_1
Xcore_307 VGND VGND VPWR VPWR core_307/HI imem_wdata_o[3] sky130_fd_sc_hd__conb_1
XFILLER_56_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_329 VGND VGND VPWR VPWR core_329/HI imem_wdata_o[25] sky130_fd_sc_hd__conb_1
XFILLER_25_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_117 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3430_ _0660_ _1207_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__o21ai_1
X_3361_ _0881_ _0899_ _1234_ _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__o31a_1
XFILLER_112_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5100_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[3\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3292_ i_decode_stage.decode_state_o\[239\] i_decode_stage.decode_state_o\[238\]
+ i_decode_stage.decode_state_o\[237\] i_decode_stage.decode_state_o\[236\] VGND VGND
+ VPWR VPWR _1197_ sky130_fd_sc_hd__and4b_1
XFILLER_112_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5031_ clknet_leaf_23_clk_i i_decode_stage.decode_state_o\[7\] net289 VGND VGND VPWR
+ VPWR i_exec_stage.exec_state_o\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4815_ _1839_ i_exec_stage.data_fwd_o\[38\] VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__and2b_1
XFILLER_159_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4746_ _2295_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XFILLER_31_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4677_ _2261_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3628_ _1433_ _1518_ _0523_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__mux2_1
XFILLER_107_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_162_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3559_ _0593_ _0448_ _0584_ _1451_ _1452_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__o221a_1
Xinput117 rf_rs2_i[26] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_1
Xinput106 rf_rs2_i[16] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5229_ clknet_leaf_16_clk_i _0228_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[27\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput128 rf_rs2_i[7] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_1
XFILLER_57_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2930_ _0324_ _0326_ i_decode_stage.reg_meta_o\[21\] VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__o21a_1
XFILLER_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2861_ i_exec_stage.data_fwd_o\[25\] _0726_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o21ai_4
X_4600_ i_decode_stage.reg_meta_o\[71\] net86 _2207_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_19_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_19_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_30_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2792_ _0585_ _0595_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a21oi_1
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_144_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4531_ i_decode_stage.reg_meta_o\[37\] net123 _2179_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__mux2_1
XFILLER_144_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4462_ net65 i_decode_stage.decode_state_o\[138\] _1967_ VGND VGND VPWR VPWR _2158_
+ sky130_fd_sc_hd__mux2_1
XFILLER_7_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3413_ _0523_ _0594_ _1177_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__a31o_1
XFILLER_89_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4393_ net210 _1927_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__and2_1
X_3344_ _1149_ _1092_ _0867_ _1198_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a22o_1
XFILLER_98_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3275_ _0525_ _1177_ _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__a21o_1
XFILLER_112_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5014_ clknet_leaf_1_clk_i _0194_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[75\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4729_ net219 i_decode_stage.fetch_state_i\[59\] _1927_ VGND VGND VPWR VPWR _2287_
+ sky130_fd_sc_hd__mux2_1
XFILLER_108_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_174_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_247 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_320 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3060_ _0622_ _0971_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__nor2_2
XFILLER_94_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3962_ i_exec_stage.exec_state_o\[1\] i_exec_stage.exec_state_o\[0\] VGND VGND VPWR
+ VPWR _1812_ sky130_fd_sc_hd__and2b_1
XFILLER_149_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3893_ _0448_ _1478_ _1769_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__o21ba_1
X_2913_ i_exec_stage.data_fwd_o\[13\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0828_
+ sky130_fd_sc_hd__or4_2
X_2844_ i_exec_stage.data_fwd_o\[27\] _0726_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__o21ai_4
XFILLER_31_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_145_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_320 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2775_ i_decode_stage.decode_state_o\[128\] _0631_ i_decode_stage.decode_state_o\[140\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__a221o_1
X_4514_ _2184_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
XFILLER_160_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4445_ _1926_ _2145_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__nor2_1
XFILLER_144_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4376_ net137 _2042_ _2090_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__a21o_1
X_3327_ _1230_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_283 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3258_ _0582_ _0691_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__nor2_1
XFILLER_58_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3189_ _1074_ _0447_ _1086_ _1087_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__a221o_1
XFILLER_100_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_353 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2560_ _0344_ _0495_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a21o_1
Xoutput207 net207 VGND VGND VPWR VPWR imem_addr_o[16] sky130_fd_sc_hd__buf_2
XFILLER_153_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput229 net229 VGND VGND VPWR VPWR imem_addr_o[7] sky130_fd_sc_hd__buf_2
Xoutput218 net218 VGND VGND VPWR VPWR imem_addr_o[26] sky130_fd_sc_hd__buf_2
X_2491_ i_mem_slice_stage.mem_state_o\[75\] _0328_ _0440_ _0330_ VGND VGND VPWR VPWR
+ net268 sky130_fd_sc_hd__a22o_1
X_4230_ i_decode_stage.decode_state_o\[58\] i_decode_stage.fetch_state_i\[50\] _1982_
+ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__mux2_1
XFILLER_141_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4161_ _1958_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_122_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3112_ _0537_ _1022_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__and2_1
X_4092_ i_decode_stage.decode_state_o\[240\] _1909_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__xor2_1
X_3043_ _0859_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nor2_1
XFILLER_64_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_392 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4994_ clknet_leaf_0_clk_i _0174_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[55\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_23_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3945_ _0759_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__inv_2
XFILLER_32_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3876_ _0417_ _0537_ _1023_ _0413_ _0424_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__o221a_1
XFILLER_31_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2827_ i_decode_stage.decode_state_o\[68\] _0731_ _0733_ VGND VGND VPWR VPWR _0742_
+ sky130_fd_sc_hd__a21oi_1
X_2758_ i_exec_stage.data_fwd_o\[6\] _0460_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__or2_1
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2689_ i_decode_stage.decode_state_o\[119\] _0493_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nand2_1
X_4428_ _1926_ _2131_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__nor2_1
XFILLER_132_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4359_ net202 _1927_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__and2_1
XFILLER_101_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_159 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3730_ _0799_ _1615_ _1158_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__a21oi_1
XTAP_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3661_ _0983_ _1549_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__xnor2_1
X_3592_ _1204_ _1476_ _1484_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__a21bo_1
X_2612_ i_mem_slice_stage.mem_state_o\[98\] _0452_ _0547_ _0455_ VGND VGND VPWR VPWR
+ net261 sky130_fd_sc_hd__a22o_1
XFILLER_161_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2543_ _0472_ _0486_ _0421_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__mux2_1
XFILLER_127_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_172 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2474_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__buf_6
X_5262_ clknet_leaf_17_clk_i _0261_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[60\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_141_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5193_ clknet_leaf_18_clk_i net359 net291 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[100\]
+ sky130_fd_sc_hd__dfrtp_1
X_4213_ _1985_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4144_ i_decode_stage.fetch_state_i\[8\] i_decode_stage.decode_state_o\[16\] _1936_
+ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__mux2_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4075_ _0554_ _0741_ _0749_ _0549_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__o22a_1
XFILLER_37_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3026_ _0897_ _0904_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4977_ clknet_leaf_24_clk_i _0157_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[124\]
+ sky130_fd_sc_hd__dfrtp_4
X_3928_ _0578_ _0978_ _0601_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__mux2_1
XFILLER_149_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3859_ _0415_ _0738_ _1736_ _0709_ _1737_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__o221a_1
XFILLER_166_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout297 net131 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__buf_6
XFILLER_101_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout286 net287 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_12
XFILLER_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_413 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4900_ clknet_leaf_15_clk_i _0080_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[234\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_65_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4831_ clknet_leaf_28_clk_i _0011_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_61_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4762_ _2303_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
XFILLER_159_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3713_ _0809_ _1595_ _0821_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__a21o_1
X_4693_ net231 i_decode_stage.fetch_state_i\[41\] _1967_ VGND VGND VPWR VPWR _2269_
+ sky130_fd_sc_hd__mux2_1
X_3644_ _1198_ _0989_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nand2_1
XFILLER_146_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_162_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3575_ _0942_ _1464_ _0852_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__o21ai_1
X_2526_ _0344_ _0464_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a21o_1
XFILLER_115_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2457_ _0345_ _0382_ _0405_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__o21ai_1
XFILLER_114_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5245_ clknet_leaf_22_clk_i _0244_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[43\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold28 i_exec_stage.exec_state_o\[32\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_69_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold17 i_decode_stage.decode_state_o\[25\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_152_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold39 i_exec_stage.exec_state_o\[37\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__clkdlybuf4s25_1
X_2388_ i_decode_stage.decode_state_o\[124\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0340_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__a31o_1
XFILLER_69_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5176_ clknet_leaf_30_clk_i net361 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[83\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4127_ net62 net60 _0722_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__and3_1
XFILLER_56_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4058_ _1872_ _1873_ _1874_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__or4_1
XFILLER_83_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xcore_308 VGND VGND VPWR VPWR core_308/HI imem_wdata_o[4] sky130_fd_sc_hd__conb_1
X_3009_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__inv_2
Xcore_319 VGND VGND VPWR VPWR core_319/HI imem_wdata_o[15] sky130_fd_sc_hd__conb_1
XFILLER_71_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_26 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3360_ _0430_ _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__nor2_1
XFILLER_98_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3291_ _0582_ _0691_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__nand2_1
XFILLER_112_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5030_ clknet_leaf_16_clk_i net402 net290 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4814_ _2329_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4745_ i_exec_stage.data_fwd_o\[3\] net152 _1839_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__mux2_1
XFILLER_162_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4676_ i_decode_stage.fetch_state_i\[0\] net200 _2234_ VGND VGND VPWR VPWR _2261_
+ sky130_fd_sc_hd__mux2_1
X_3627_ _1472_ _1517_ _0422_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__mux2_1
XFILLER_162_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3558_ _0662_ _1115_ _1348_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__or3_1
XFILLER_115_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2509_ _0376_ _0377_ _0378_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__or3_1
XFILLER_1_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3489_ _0935_ _1366_ _1379_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__a21oi_1
Xinput118 rf_rs2_i[27] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
Xinput107 rf_rs2_i[17] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_1
Xinput129 rf_rs2_i[8] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
X_5228_ clknet_leaf_18_clk_i _0227_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[26\]
+ sky130_fd_sc_hd__dfrtp_1
X_5159_ clknet_leaf_4_clk_i net411 net296 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[66\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_57_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_302 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2860_ i_decode_stage.reg_meta_o\[30\] _0727_ _0386_ _0774_ VGND VGND VPWR VPWR _0775_
+ sky130_fd_sc_hd__a211o_1
XFILLER_30_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_157_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2791_ _0590_ _0661_ _0708_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__o211a_1
XFILLER_30_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4530_ _2192_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
X_4461_ _2157_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3412_ _0545_ _1216_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__and2_2
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4392_ _2101_ _2102_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__nor2_1
X_3343_ _0413_ _0867_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__nor2_1
XFILLER_112_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3274_ _0525_ _1178_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nor2_1
XFILLER_98_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5013_ clknet_leaf_1_clk_i _0193_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[74\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2989_ _0677_ _0880_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__and2b_1
XFILLER_22_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4728_ _2286_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4659_ i_decode_stage.fetch_state_i\[19\] _2103_ _2234_ VGND VGND VPWR VPWR _2257_
+ sky130_fd_sc_hd__mux2_1
XFILLER_174_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_410 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_166_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3961_ net31 net17 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__mux2_1
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2912_ _0324_ _0326_ i_decode_stage.reg_meta_o\[18\] VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__o21a_1
X_3892_ _1195_ _1035_ _1767_ _0545_ _1768_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__a221o_1
XFILLER_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2843_ i_decode_stage.reg_meta_o\[32\] _0727_ _0386_ _0757_ VGND VGND VPWR VPWR _0758_
+ sky130_fd_sc_hd__a211o_1
XFILLER_31_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2774_ i_exec_stage.data_fwd_o\[5\] _0692_ _0460_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__mux2_2
XFILLER_145_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4513_ i_decode_stage.reg_meta_o\[28\] net113 _2179_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__mux2_1
XFILLER_8_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4444_ net221 _2140_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__and2_1
XFILLER_113_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4375_ net206 _1936_ _2045_ _2089_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__a22o_1
X_3326_ _1215_ _1225_ _1229_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__or3b_1
XFILLER_113_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3257_ _0707_ _0691_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__and2_1
XFILLER_86_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_17 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3188_ _1088_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__nor2_1
XFILLER_66_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_18_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_18_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_65_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput208 net208 VGND VGND VPWR VPWR imem_addr_o[17] sky130_fd_sc_hd__buf_2
XFILLER_142_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2490_ i_mem_slice_stage.mem_state_o\[43\] i_mem_slice_stage.mem_state_o\[4\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__mux2_2
XFILLER_5_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput219 net219 VGND VGND VPWR VPWR imem_addr_o[27] sky130_fd_sc_hd__clkbuf_4
XFILLER_4_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4160_ i_decode_stage.fetch_state_i\[16\] i_decode_stage.decode_state_o\[24\] _1936_
+ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__mux2_1
X_3111_ _0537_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nor2_1
XFILLER_68_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4091_ _1890_ _1891_ i_decode_stage.decode_state_o\[241\] VGND VGND VPWR VPWR _1909_
+ sky130_fd_sc_hd__o21ba_1
XFILLER_68_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3042_ _0936_ _0947_ _0948_ _0952_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__a221oi_2
XFILLER_83_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4993_ clknet_leaf_30_clk_i _0173_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[54\]
+ sky130_fd_sc_hd__dfrtp_1
X_3944_ _0601_ _1799_ _1800_ _0917_ _1776_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__a221o_1
XFILLER_23_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3875_ _1198_ _1023_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__nand2_1
X_2826_ i_exec_stage.data_fwd_o\[29\] _0726_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__o21ai_4
XFILLER_31_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2757_ _0346_ i_decode_stage.decode_state_o\[130\] _0347_ _0676_ VGND VGND VPWR VPWR
+ _0677_ sky130_fd_sc_hd__a22oi_4
XFILLER_145_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2688_ _0358_ _0611_ _0613_ _0614_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o31a_2
XFILLER_2_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4427_ net218 _2125_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__and2_1
XFILLER_160_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4358_ _2075_ _2076_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__nor2_1
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3309_ _0430_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__or2_1
X_4289_ _2027_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
XFILLER_47_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_159_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3660_ _0991_ _1527_ _0989_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__o21bai_1
XFILLER_70_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_174_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3591_ _0415_ _0852_ _1481_ _1483_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__o211a_1
X_2611_ i_mem_slice_stage.mem_state_o\[66\] i_mem_slice_stage.mem_state_o\[27\] _0453_
+ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__mux2_1
XFILLER_173_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2542_ _0344_ _0478_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a21o_1
XFILLER_127_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5261_ clknet_leaf_17_clk_i _0260_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[59\]
+ sky130_fd_sc_hd__dfrtp_1
X_2473_ _0418_ _0413_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__or2_1
XFILLER_87_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4212_ i_decode_stage.decode_state_o\[49\] i_decode_stage.fetch_state_i\[41\] _1982_
+ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__mux2_1
XFILLER_142_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5192_ clknet_leaf_18_clk_i net366 net291 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[99\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_122_390 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4143_ _1949_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_4074_ _1890_ _1891_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__or2_1
XFILLER_68_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3025_ _0913_ _0921_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__or3b_1
XFILLER_83_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4976_ clknet_leaf_2_clk_i _0156_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[37\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3927_ _1790_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__inv_2
X_3858_ _0417_ _0532_ _0737_ _0424_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__o22a_1
XFILLER_137_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3789_ _0771_ _0779_ _0772_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__o21a_1
X_2809_ i_decode_stage.decode_state_o\[4\] i_decode_stage.decode_state_o\[3\] i_exec_stage.valid
+ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__o21a_1
XFILLER_152_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout287 net288 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__clkbuf_16
XFILLER_47_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_447 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_425 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4830_ clknet_leaf_28_clk_i _0010_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_2491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4761_ i_exec_stage.data_fwd_o\[11\] net132 _1839_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__mux2_1
XFILLER_159_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3712_ _0797_ _0798_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__or2_1
X_4692_ _2268_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3643_ _1129_ _1127_ _1479_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__a21oi_1
XFILLER_161_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3574_ _0852_ _0942_ _1464_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__or3_1
X_2525_ _0465_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__and2_1
XFILLER_130_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2456_ _0345_ _0382_ _0405_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__or3_1
XFILLER_114_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5244_ clknet_leaf_26_clk_i _0243_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[42\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold29 i_exec_stage.exec_state_o\[67\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_69_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold18 i_exec_stage.exec_state_o\[62\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5175_ clknet_leaf_28_clk_i net368 net283 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[82\]
+ sky130_fd_sc_hd__dfrtp_1
X_2387_ _0338_ i_decode_stage.decode_state_o\[147\] i_decode_stage.decode_state_o\[40\]
+ _0339_ _2332_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a221o_1
XFILLER_84_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4126_ i_decode_stage.decode_state_o\[5\] _1928_ _1935_ _1940_ VGND VGND VPWR VPWR
+ _0003_ sky130_fd_sc_hd__a211o_1
XFILLER_69_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4057_ _0630_ _0925_ _1869_ _0655_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__a22o_1
Xcore_309 VGND VGND VPWR VPWR core_309/HI imem_wdata_o[5] sky130_fd_sc_hd__conb_1
XFILLER_56_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3008_ _0650_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__xnor2_2
XFILLER_169_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4959_ clknet_leaf_1_clk_i _0139_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_61_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3290_ _0413_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__inv_2
XFILLER_112_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4813_ i_exec_stage.data_fwd_o\[37\] i_decode_stage.decode_state_o\[140\] _1838_
+ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__mux2_1
XFILLER_22_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4744_ _2294_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
XFILLER_159_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4675_ _2260_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3626_ _0344_ _0512_ _0623_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__a21o_1
XFILLER_162_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3557_ _0707_ _1272_ _1322_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__o21a_1
XFILLER_143_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_400 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2508_ i_mem_slice_stage.mem_state_o\[94\] _0452_ _0454_ _0455_ VGND VGND VPWR VPWR
+ net257 sky130_fd_sc_hd__a22o_1
XFILLER_130_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3488_ _0948_ _1377_ _0952_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__o21ai_1
Xinput108 rf_rs2_i[18] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
X_5227_ clknet_leaf_18_clk_i _0226_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[25\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput119 rf_rs2_i[28] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_1
X_2439_ i_exec_stage.data_fwd_o\[2\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0390_
+ sky130_fd_sc_hd__or4_1
XFILLER_69_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5158_ clknet_leaf_5_clk_i net346 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[65\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_96_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4109_ net33 net66 _0720_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__nand3_4
X_5089_ clknet_leaf_18_clk_i i_decode_stage.decode_state_o\[33\] net291 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[64\] sky130_fd_sc_hd__dfrtp_1
XFILLER_56_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2790_ _0384_ net193 _0446_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__o21ai_4
XFILLER_8_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4460_ net64 i_decode_stage.decode_state_o\[137\] _1967_ VGND VGND VPWR VPWR _2157_
+ sky130_fd_sc_hd__mux2_1
XFILLER_7_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3411_ _1182_ _1178_ _0525_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__mux2_1
X_4391_ net209 _2095_ net210 VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__a21oi_1
X_3342_ _1087_ _1238_ _1242_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__a211o_1
XFILLER_125_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3273_ _0558_ _0538_ _0527_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__mux2_1
XFILLER_112_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5012_ clknet_leaf_1_clk_i _0192_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[73\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2988_ _0709_ _0695_ _0898_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a31o_1
XFILLER_135_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4727_ net218 i_decode_stage.fetch_state_i\[58\] _1927_ VGND VGND VPWR VPWR _2286_
+ sky130_fd_sc_hd__mux2_1
XFILLER_147_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4658_ _2256_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3609_ _0448_ _1421_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__nand2_2
XFILLER_123_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput90 rf_rs1_i[30] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_1
XFILLER_162_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4589_ _2222_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_422 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_164_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3960_ i_exec_stage.exec_state_o\[1\] _1805_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__nor2b_4
XFILLER_90_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2911_ _2336_ _2341_ net245 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__and3_1
XFILLER_44_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3891_ _0424_ _1032_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__nor2_1
X_2842_ _2336_ _2341_ net260 VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__and3_1
X_2773_ net268 i_decode_stage.reg_meta_o\[48\] _0457_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__mux2_1
XFILLER_31_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4512_ _2183_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
XFILLER_105_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4443_ net151 _1924_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__or2_1
X_4374_ net206 _2085_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__xor2_1
X_3325_ _1226_ _1196_ _1227_ _1228_ _1158_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__a311o_1
XFILLER_113_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3256_ _0887_ _0889_ _0892_ _0894_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__o31a_1
XFILLER_113_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3187_ _0523_ _1095_ _1096_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__o22a_1
XFILLER_94_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_420 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput209 net209 VGND VGND VPWR VPWR imem_addr_o[18] sky130_fd_sc_hd__buf_2
XFILLER_5_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3110_ _0384_ _1020_ _1021_ _0752_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__o211a_1
XFILLER_68_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4090_ _1904_ _1895_ _1907_ _1890_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__a31o_1
X_3041_ _0633_ _0927_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nor2_1
XFILLER_83_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4992_ clknet_leaf_0_clk_i _0172_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[53\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3943_ i_decode_stage.decode_state_o\[0\] _1110_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__and2_1
XFILLER_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3874_ _0448_ _1452_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__nor2_1
XFILLER_31_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2825_ i_decode_stage.reg_meta_o\[34\] _0727_ _0386_ _0739_ VGND VGND VPWR VPWR _0740_
+ sky130_fd_sc_hd__a211o_1
XFILLER_145_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2756_ i_exec_stage.data_fwd_o\[7\] _0675_ _0460_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__mux2_2
XFILLER_160_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2687_ i_exec_stage.data_fwd_o\[16\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0614_
+ sky130_fd_sc_hd__or4_1
XFILLER_160_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4426_ _1688_ _2129_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__nand2_1
XFILLER_113_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4357_ net202 _2071_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__nor2_1
X_3308_ _0886_ _0896_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__nor2_1
XFILLER_100_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4288_ _1933_ _2026_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__or2_1
X_3239_ _0343_ _0382_ _0405_ _0420_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__o31a_1
XFILLER_104_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_386 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2610_ _0540_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__nand2_1
X_3590_ _0417_ _0617_ _0851_ _0419_ _1482_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__o221a_1
X_2541_ _0465_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__and2_1
XFILLER_142_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2472_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__buf_8
XFILLER_142_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5260_ clknet_leaf_17_clk_i _0259_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[58\]
+ sky130_fd_sc_hd__dfrtp_1
X_4211_ _1984_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_5191_ clknet_leaf_16_clk_i net393 net291 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[98\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_110_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4142_ i_decode_stage.fetch_state_i\[7\] i_decode_stage.decode_state_o\[15\] _1936_
+ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__mux2_1
X_4073_ _0543_ _1030_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__and2_1
XFILLER_68_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3024_ _0928_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__nor2_1
XFILLER_37_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4975_ clknet_leaf_6_clk_i _0155_ net294 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[36\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3926_ _0519_ _0986_ _0601_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__mux2_1
XFILLER_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3857_ _1313_ _1435_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__nor2_1
Xclkbuf_leaf_17_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_17_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_50_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3788_ _0771_ _0779_ _1638_ _0772_ _0764_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__o311a_1
X_2808_ _0724_ VGND VGND VPWR VPWR i_exec_stage.valid sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_145_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2739_ _0525_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__buf_6
XFILLER_117_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_160_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4409_ net215 _2112_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__nor2_1
XFILLER_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout288 net131 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_16
XFILLER_47_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_459 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_481 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4760_ _2302_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XFILLER_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3711_ _0411_ _1585_ _1594_ _1597_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__a211o_4
X_4691_ net230 i_decode_stage.fetch_state_i\[40\] _1967_ VGND VGND VPWR VPWR _2268_
+ sky130_fd_sc_hd__mux2_1
XFILLER_174_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3642_ _0991_ _0996_ _1529_ _1531_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__o31a_1
XFILLER_174_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3573_ _0411_ _1447_ _1463_ _1466_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__a211o_4
X_2524_ _0451_ _0468_ _0462_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_142_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2455_ _0394_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__xnor2_4
XFILLER_69_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5243_ clknet_leaf_27_clk_i _0242_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[41\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold19 i_exec_stage.exec_state_o\[29\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_130_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2386_ _0337_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__nor2_8
X_5174_ clknet_leaf_28_clk_i net400 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[81\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4125_ _1936_ _1939_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__nor2_1
XFILLER_69_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4056_ _0638_ _0829_ _0838_ _0600_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__a22o_1
XFILLER_83_256 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3007_ _2333_ _0917_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__a21oi_2
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4958_ clknet_leaf_3_clk_i _0138_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4889_ clknet_leaf_11_clk_i _0069_ net295 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[117\]
+ sky130_fd_sc_hd__dfrtp_1
X_3909_ _1778_ _1774_ _1779_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__a21o_1
XFILLER_137_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_280 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4812_ _2328_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
XFILLER_61_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4743_ i_exec_stage.data_fwd_o\[2\] i_exec_stage.alu_out\[1\] _1839_ VGND VGND VPWR
+ VPWR _2294_ sky130_fd_sc_hd__mux2_1
XFILLER_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4674_ i_decode_stage.fetch_state_i\[31\] _2154_ _2234_ VGND VGND VPWR VPWR _2260_
+ sky130_fd_sc_hd__mux2_1
XFILLER_135_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3625_ _0424_ _1515_ _0965_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__a21o_1
X_3556_ _0707_ _1288_ _1449_ _1129_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__o211a_1
XFILLER_1_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2507_ _0330_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__buf_6
XFILLER_170_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3487_ _0952_ _0948_ _1377_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__or3_1
Xinput109 rf_rs2_i[19] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
X_5226_ clknet_leaf_15_clk_i _0225_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[24\]
+ sky130_fd_sc_hd__dfrtp_1
X_2438_ _0324_ _0326_ i_decode_stage.reg_meta_o\[7\] VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__o21a_1
XFILLER_130_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5157_ clknet_leaf_5_clk_i net365 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[64\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_69_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2369_ _2334_ _2335_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__or2_1
X_5088_ clknet_leaf_23_clk_i net408 net289 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
X_4108_ _1839_ i_decode_stage.valid_i _1840_ _1924_ _1925_ VGND VGND VPWR VPWR _0000_
+ sky130_fd_sc_hd__a41o_1
X_4039_ _1853_ _1856_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__nand2_1
XFILLER_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3410_ _0876_ _0901_ _1261_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__or3_1
XFILLER_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4390_ net209 net210 _2095_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__and3_1
X_3341_ _0660_ _0685_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__a21oi_1
XFILLER_98_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3272_ _0540_ _0586_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__nor2_1
XFILLER_112_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5011_ clknet_leaf_0_clk_i _0191_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[72\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_392 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_223 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2987_ _0683_ _0866_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__and2b_1
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4726_ _2285_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4657_ i_decode_stage.fetch_state_i\[18\] _2099_ _2234_ VGND VGND VPWR VPWR _2256_
+ sky130_fd_sc_hd__mux2_1
XFILLER_174_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3608_ _1204_ _1045_ _1498_ _0707_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__o221a_1
Xinput91 rf_rs1_i[31] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_1
Xinput80 rf_rs1_i[21] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_1
XFILLER_162_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4588_ i_decode_stage.reg_meta_o\[65\] net80 _2207_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__mux2_1
XFILLER_1_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3539_ _1357_ _1433_ _0523_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__mux2_1
XFILLER_131_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5209_ clknet_leaf_28_clk_i _0208_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_85_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_172_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2910_ _0800_ _0809_ _0817_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a31o_1
XFILLER_44_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3890_ _0419_ _1032_ _0416_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__o21bai_1
XFILLER_43_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2841_ _0754_ _0755_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__and2_1
X_2772_ _0450_ _0689_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__o21a_4
XFILLER_157_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4511_ i_decode_stage.reg_meta_o\[27\] net112 _2179_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__mux2_1
XFILLER_172_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4442_ net220 _1928_ _2139_ _2143_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a22o_1
XFILLER_7_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4373_ net136 _2042_ _2045_ _2087_ _2088_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__a221o_1
X_3324_ _1196_ _1227_ _1226_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__a21oi_2
XFILLER_113_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3255_ _1143_ _1147_ _1151_ _1160_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__nand4_4
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3186_ _0422_ _1097_ _0523_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__o21ai_1
XFILLER_82_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4709_ net208 i_decode_stage.fetch_state_i\[49\] _1927_ VGND VGND VPWR VPWR _2277_
+ sky130_fd_sc_hd__mux2_1
XFILLER_135_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_163_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_315 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3040_ _0950_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__nand2_2
XFILLER_64_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4991_ clknet_leaf_30_clk_i _0171_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[52\]
+ sky130_fd_sc_hd__dfrtp_1
X_3942_ _0768_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__inv_2
X_3873_ _0709_ _1451_ _1479_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__a21oi_1
X_2824_ _2336_ _2341_ net262 VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__and3_1
XFILLER_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2755_ net270 i_decode_stage.reg_meta_o\[50\] _0457_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__mux2_1
XFILLER_160_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2686_ _0363_ _0369_ _0374_ net248 VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__and4_1
XFILLER_144_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4425_ _1924_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__inv_2
XFILLER_160_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4356_ net231 net201 net202 _2065_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__and4_1
X_3307_ _1209_ _1210_ _0885_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__a21oi_1
XFILLER_113_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4287_ i_decode_stage.decode_state_o\[233\] _2022_ _0722_ VGND VGND VPWR VPWR _2026_
+ sky130_fd_sc_hd__mux2_1
X_3238_ i_decode_stage.decode_state_o\[237\] _0413_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__nor2_2
XFILLER_67_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3169_ _0343_ _0672_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__a21o_1
XTAP_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_168_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2540_ _0451_ _0481_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__o21ai_4
XFILLER_142_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2471_ _0394_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__clkbuf_16
XFILLER_5_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4210_ i_decode_stage.decode_state_o\[48\] i_decode_stage.fetch_state_i\[40\] _1982_
+ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__mux2_1
XFILLER_141_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5190_ clknet_leaf_18_clk_i net364 net291 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[97\]
+ sky130_fd_sc_hd__dfrtp_1
Xclkbuf_0_clk_i clk_i VGND VGND VPWR VPWR clknet_0_clk_i sky130_fd_sc_hd__clkbuf_16
XFILLER_96_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4141_ _1948_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_4072_ _0543_ _1030_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__nor2_1
XFILLER_110_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3023_ _0656_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__xor2_4
XFILLER_83_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4974_ clknet_leaf_2_clk_i _0154_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[35\]
+ sky130_fd_sc_hd__dfrtp_1
X_3925_ _1789_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_1
XFILLER_165_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3856_ _1326_ _1588_ _1734_ _1041_ _1441_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__o221a_1
XFILLER_20_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3787_ _1156_ _1655_ _1656_ _1660_ _1669_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__a311o_4
X_2807_ i_decode_stage.valid_o _0722_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__and2_1
X_2738_ _0625_ _0659_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__mux2_1
XFILLER_117_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4408_ net214 _1929_ _2115_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a21o_1
X_2669_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[57\] VGND VGND VPWR VPWR _0598_
+ sky130_fd_sc_hd__o31a_1
XFILLER_59_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4339_ net158 _2047_ _2048_ _2061_ _2062_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__o221a_1
XFILLER_87_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout289 net131 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_12
XFILLER_75_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_118 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_164_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_163_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3710_ _0809_ _1595_ _1596_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__o21a_1
XTAP_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4690_ _2267_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
XFILLER_41_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3641_ _0430_ _1530_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__nor2_1
XFILLER_174_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3572_ _1464_ _1465_ _1156_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__and3b_1
XFILLER_127_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2523_ _0346_ i_decode_stage.decode_state_o\[128\] VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__or2b_1
XFILLER_6_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2454_ _0347_ _0402_ _0403_ _0346_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a22oi_4
X_5242_ clknet_leaf_26_clk_i _0241_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[40\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2385_ i_decode_stage.decode_state_o\[232\] VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__inv_2
XFILLER_68_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5173_ clknet_leaf_29_clk_i net386 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[80\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_110_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4124_ _1937_ _1938_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__nand2_1
XFILLER_69_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput1 dmem_rdata_i[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XFILLER_84_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4055_ _0671_ _0908_ _1868_ _0649_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__a22o_1
XFILLER_84_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3006_ i_decode_stage.decode_state_o\[49\] _0339_ _0751_ i_decode_stage.decode_state_o\[133\]
+ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__a22o_1
XFILLER_37_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_169_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4957_ clknet_leaf_1_clk_i _0137_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4888_ clknet_leaf_11_clk_i _0068_ net295 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[0\]
+ sky130_fd_sc_hd__dfrtp_4
X_3908_ _0578_ _1774_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__nor2_1
X_3839_ _0422_ _1718_ _0525_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__a21oi_1
XFILLER_138_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_156_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_16_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_16_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_66_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4811_ i_exec_stage.data_fwd_o\[36\] i_decode_stage.decode_state_o\[139\] _1838_
+ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__mux2_1
XFILLER_61_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4742_ _2293_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4673_ i_decode_stage.fetch_state_i\[30\] _1929_ _2152_ VGND VGND VPWR VPWR _0231_
+ sky130_fd_sc_hd__a21o_1
X_3624_ _0417_ _0512_ _0964_ _0413_ _1514_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__o221a_1
XFILLER_174_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3555_ _0707_ _1273_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__nand2_1
XFILLER_127_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2506_ i_mem_slice_stage.mem_state_o\[62\] i_mem_slice_stage.mem_state_o\[23\] _0453_
+ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_2
X_3486_ _0411_ _1367_ _1376_ _1383_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__a211o_4
XFILLER_0_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2437_ _2336_ _2341_ net253 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__and3_1
X_5225_ clknet_leaf_16_clk_i _0224_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5156_ clknet_leaf_7_clk_i net362 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
X_2368_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__buf_4
XFILLER_69_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5087_ clknet_leaf_22_clk_i net389 net289 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
X_4107_ _1839_ _1840_ i_decode_stage.valid_o VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__a21boi_1
XFILLER_29_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4038_ _0519_ _0701_ _1854_ _1855_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput190 net190 VGND VGND VPWR VPWR dmem_wdata_o[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_95_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_156_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_171_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3340_ _0662_ _0659_ _1088_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__a21o_1
XFILLER_125_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3271_ _0662_ _1173_ _1174_ _1175_ _0707_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a221o_1
XFILLER_112_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5010_ clknet_leaf_3_clk_i _0190_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[71\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_235 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2986_ _0683_ _0866_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__xnor2_1
XFILLER_159_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4725_ net217 i_decode_stage.fetch_state_i\[57\] _1927_ VGND VGND VPWR VPWR _2285_
+ sky130_fd_sc_hd__mux2_1
XFILLER_135_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4656_ _2255_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
X_3607_ _0707_ _1330_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__nand2_1
Xinput81 rf_rs1_i[22] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_1
X_4587_ _2221_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
Xinput70 rf_rs1_i[12] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
XFILLER_162_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3538_ _1388_ _1432_ _0421_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__mux2_1
Xinput92 rf_rs1_i[3] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_1
XFILLER_130_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_102 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3469_ _0935_ _1366_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__xor2_1
XFILLER_103_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5208_ clknet_leaf_27_clk_i _0207_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_5139_ clknet_leaf_5_clk_i net370 net296 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[46\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_69_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2840_ _0551_ _0753_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__or2_1
XFILLER_92_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2771_ i_decode_stage.decode_state_o\[127\] _0631_ i_decode_stage.decode_state_o\[139\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a221o_1
XFILLER_157_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4510_ _2182_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
XFILLER_156_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4441_ _2042_ _2142_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__or2_1
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4372_ net205 _1927_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__and2_1
X_3323_ _1148_ _1145_ _0891_ _1163_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__a211o_1
XFILLER_98_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3254_ _0448_ _1041_ _1154_ _1159_ _0892_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__o32a_1
XFILLER_113_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3185_ _0691_ _0703_ _0344_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__mux2_1
XFILLER_93_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_385 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2969_ _0677_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__xnor2_4
XFILLER_136_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4708_ _2276_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4639_ i_decode_stage.fetch_state_i\[9\] _2069_ _2234_ VGND VGND VPWR VPWR _2247_
+ sky130_fd_sc_hd__mux2_1
XFILLER_162_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4990_ clknet_leaf_30_clk_i _0170_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[51\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3941_ _1110_ _0776_ _1798_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__o21ai_1
XFILLER_149_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3872_ _0709_ _1459_ _1749_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__o21ba_1
XFILLER_149_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2823_ _0736_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__or2_2
XFILLER_164_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2754_ i_mem_slice_stage.mem_state_o\[77\] _0328_ _0674_ _0330_ VGND VGND VPWR VPWR
+ net270 sky130_fd_sc_hd__a22o_2
XFILLER_144_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2685_ i_mem_slice_stage.mem_state_o\[86\] _0328_ _0612_ _0330_ VGND VGND VPWR VPWR
+ net248 sky130_fd_sc_hd__a22o_1
XFILLER_160_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4424_ net217 _1929_ _2128_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a21o_1
XFILLER_160_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_338 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4355_ net132 _2047_ _2048_ _2073_ _2074_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__o221a_1
X_3306_ _0417_ _0883_ _0884_ _0413_ _0424_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__o221a_1
XFILLER_99_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4286_ _2025_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_86_447 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3237_ _1128_ _1132_ _1142_ _1129_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a22o_1
XFILLER_73_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3168_ _0343_ _0945_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__nor2_1
XTAP_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3099_ _1009_ _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__nand2_1
XFILLER_70_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_469 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2470_ _0394_ _0404_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__or2_1
XFILLER_115_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4140_ i_decode_stage.fetch_state_i\[6\] i_decode_stage.decode_state_o\[14\] _1936_
+ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__mux2_1
XFILLER_110_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4071_ _1841_ _1888_ _1842_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__o21bai_1
X_3022_ _2333_ _0932_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21oi_4
XFILLER_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4973_ clknet_leaf_1_clk_i _0153_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[34\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3924_ net178 _1788_ _0601_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
XFILLER_20_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3855_ _1662_ _1733_ _0660_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__mux2_1
XFILLER_117_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3786_ _1198_ _0771_ _1666_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__a211o_1
X_2806_ _0723_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__clkbuf_2
X_2737_ _0523_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__buf_8
XFILLER_145_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2668_ _0363_ _0369_ _0374_ net246 VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and4_1
XFILLER_160_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4407_ net144 _1924_ _2042_ _2114_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__o22a_1
XFILLER_160_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2599_ _0346_ i_decode_stage.decode_state_o\[134\] VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__or2b_1
XFILLER_113_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_414 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4338_ net228 _1840_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__or2_1
X_4269_ i_decode_stage.decode_state_o\[131\] net53 _2012_ VGND VGND VPWR VPWR _2014_
+ sky130_fd_sc_hd__mux2_1
XFILLER_140_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_255 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_419 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3640_ _0996_ _1529_ _0991_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__o21a_1
X_3571_ _0858_ _0940_ _1429_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__or3_1
XFILLER_155_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2522_ i_exec_stage.data_fwd_o\[25\] _0467_ _0460_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__mux2_2
XFILLER_142_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2453_ i_decode_stage.decode_state_o\[125\] i_decode_stage.decode_state_o\[137\]
+ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux2_1
X_5241_ clknet_leaf_21_clk_i _0240_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[39\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2384_ i_decode_stage.decode_state_o\[233\] VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__inv_2
X_5172_ clknet_leaf_29_clk_i net401 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[79\]
+ sky130_fd_sc_hd__dfrtp_1
X_4123_ net60 net61 net62 VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__and3b_1
XFILLER_68_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput2 dmem_rdata_i[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_110_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4054_ _0615_ _1785_ _0855_ _0606_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__a22o_1
XFILLER_84_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3005_ _0726_ _0914_ _0915_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a31oi_4
XFILLER_37_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4956_ clknet_leaf_1_clk_i _0136_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_165_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3907_ _0386_ _0922_ _0923_ _0924_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__o31a_1
X_4887_ clknet_leaf_19_clk_i _0067_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[71\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3838_ _0345_ _0556_ _1067_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__a21o_1
XFILLER_153_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3769_ _1640_ _1641_ _1649_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__o211a_1
XFILLER_161_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_142_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_156_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4810_ _2327_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
XFILLER_34_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4741_ i_exec_stage.data_fwd_o\[1\] i_exec_stage.alu_out\[0\] _1839_ VGND VGND VPWR
+ VPWR _2293_ sky130_fd_sc_hd__mux2_1
XFILLER_159_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4672_ i_decode_stage.fetch_state_i\[29\] _1929_ _2147_ VGND VGND VPWR VPWR _0230_
+ sky130_fd_sc_hd__a21o_1
XFILLER_174_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3623_ _1198_ _0964_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__nand2_1
XFILLER_174_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3554_ _0608_ _0857_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__nor2_1
XFILLER_143_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2505_ i_mem_slice_stage.mem_state_o\[36\] VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__buf_12
X_3485_ _1377_ _1378_ _1381_ _1382_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_103_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2436_ i_mem_slice_stage.mem_state_o\[72\] _0328_ _0387_ _0330_ VGND VGND VPWR VPWR
+ net253 sky130_fd_sc_hd__a22o_2
X_5224_ clknet_leaf_19_clk_i _0223_ net288 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5155_ clknet_leaf_10_clk_i net358 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2367_ _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__or3_1
XFILLER_69_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4106_ i_decode_stage.valid_o _1923_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__nand2_8
X_5086_ clknet_leaf_19_clk_i i_decode_stage.decode_state_o\[30\] net288 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[61\] sky130_fd_sc_hd__dfrtp_1
XFILLER_56_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4037_ _0336_ _0381_ _0391_ _0402_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__o22ai_1
XFILLER_84_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4939_ clknet_leaf_19_clk_i _0119_ net288 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dfrtp_4
XFILLER_40_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_271 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_241 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput191 net191 VGND VGND VPWR VPWR dmem_wdata_o[31] sky130_fd_sc_hd__clkbuf_4
XFILLER_121_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput180 net180 VGND VGND VPWR VPWR dmem_wdata_o[21] sky130_fd_sc_hd__clkbuf_4
XFILLER_94_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_156_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3270_ _0422_ _0696_ _0662_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__a21oi_1
XFILLER_125_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2985_ _0869_ _0882_ _0886_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__or4_1
X_4724_ _2284_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4655_ i_decode_stage.fetch_state_i\[17\] _2097_ _2234_ VGND VGND VPWR VPWR _2255_
+ sky130_fd_sc_hd__mux2_1
X_3606_ _1414_ _1497_ _0660_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__mux2_1
Xinput60 imem_rdata_i[4] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_4
X_4586_ i_decode_stage.reg_meta_o\[64\] net79 _2207_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__mux2_1
Xinput82 rf_rs1_i[23] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
Xinput71 rf_rs1_i[13] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_1
X_3537_ _0344_ _0603_ _0641_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__a21o_1
XFILLER_115_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput93 rf_rs1_i[4] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_1
XFILLER_143_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3468_ _1340_ _1364_ _1365_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__a21o_1
X_3399_ _1169_ _1181_ _0525_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__mux2_1
XFILLER_130_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5207_ clknet_leaf_27_clk_i _0206_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_2419_ i_decode_stage.decode_state_o\[122\] net278 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__or2b_1
X_5138_ clknet_leaf_7_clk_i net369 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[45\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_29_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5069_ clknet_leaf_29_clk_i i_decode_stage.decode_state_o\[13\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[44\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_15_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_15_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_107_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_164_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2770_ _0358_ _0686_ _0687_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__o31a_2
XFILLER_12_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_355 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4440_ _2140_ _0722_ _2141_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__and3b_1
XFILLER_125_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4371_ _2085_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__nor2_1
XFILLER_140_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3322_ _0884_ _0885_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__or2_1
XFILLER_98_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3253_ _1156_ _0889_ _1145_ _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_98_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3184_ _0345_ _0404_ _1042_ _0421_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__o211a_1
XFILLER_112_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2968_ _2333_ net195 _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a21oi_4
XFILLER_22_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4707_ net207 i_decode_stage.fetch_state_i\[48\] _1927_ VGND VGND VPWR VPWR _2276_
+ sky130_fd_sc_hd__mux2_1
XFILLER_136_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2899_ _2333_ _0812_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a21o_1
X_4638_ _2246_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4569_ _2212_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XFILLER_143_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3940_ _0336_ _1774_ _1112_ _0908_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__o22a_1
XFILLER_91_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3871_ _0709_ _0712_ _1326_ _1604_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__o221a_1
X_2822_ _0532_ _0735_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__and2_1
XFILLER_157_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2753_ i_mem_slice_stage.mem_state_o\[45\] i_mem_slice_stage.mem_state_o\[6\] _0453_
+ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__mux2_1
XFILLER_117_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_144_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2684_ i_mem_slice_stage.mem_state_o\[54\] i_mem_slice_stage.mem_state_o\[15\] _0453_
+ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__mux2_1
XFILLER_172_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4423_ net147 _1924_ _2042_ _2127_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__o22a_1
XFILLER_125_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4354_ net201 _1840_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__or2_1
XFILLER_140_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3305_ _1198_ _0884_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nand2_1
XFILLER_113_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_106 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4285_ i_decode_stage.decode_state_o\[232\] _2024_ _2012_ VGND VGND VPWR VPWR _2025_
+ sky130_fd_sc_hd__mux2_1
X_3236_ _1137_ _1141_ _0590_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__mux2_1
XFILLER_86_459 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3167_ _1076_ _1078_ _0421_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux2_1
XFILLER_104_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3098_ _0568_ _0761_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__and2b_1
XFILLER_82_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4070_ _1848_ _1887_ _1850_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__o21a_1
XFILLER_110_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3021_ i_decode_stage.decode_state_o\[50\] _0339_ _0751_ i_decode_stage.decode_state_o\[134\]
+ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a22o_1
XFILLER_95_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_161 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4972_ clknet_leaf_2_clk_i _0152_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[33\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_63_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3923_ _0961_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__inv_2
XFILLER_149_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3854_ _1698_ _1732_ _0422_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__mux2_1
XFILLER_20_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2805_ i_decode_stage.valid_o i_decode_stage.decode_state_o\[3\] _0722_ VGND VGND
+ VPWR VPWR _0723_ sky130_fd_sc_hd__and3_1
XFILLER_20_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3785_ _1199_ _0772_ _1657_ _1144_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__a221o_1
X_2736_ _0642_ _0658_ _0422_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__mux2_1
XFILLER_118_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2667_ i_mem_slice_stage.mem_state_o\[84\] _0328_ _0596_ _0330_ VGND VGND VPWR VPWR
+ net246 sky130_fd_sc_hd__a22o_1
XFILLER_160_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4406_ _2112_ _0722_ _2113_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__and3b_1
XFILLER_99_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2598_ i_exec_stage.data_fwd_o\[31\] _0534_ _0460_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__mux2_2
XFILLER_160_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4337_ _2059_ _2060_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__and2_1
X_4268_ _2013_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
XFILLER_115_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3219_ _1122_ _1124_ _0525_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__mux2_1
XFILLER_28_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4199_ i_decode_stage.decode_state_o\[43\] i_decode_stage.fetch_state_i\[35\] _1840_
+ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__mux2_1
XTAP_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3570_ _0940_ _1429_ _0858_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__o21a_1
XFILLER_142_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2521_ net258 i_decode_stage.reg_meta_o\[68\] _0457_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__mux2_1
XFILLER_142_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5240_ clknet_leaf_27_clk_i _0239_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[38\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_114_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2452_ _0358_ _0395_ _0399_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__o31ai_4
XFILLER_5_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2383_ _0306_ _0322_ _0331_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__a31oi_4
X_5171_ clknet_leaf_28_clk_i net382 net282 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[78\]
+ sky130_fd_sc_hd__dfrtp_1
X_4122_ net56 net34 net45 VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__and3_2
XFILLER_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4053_ _0649_ _1868_ _1869_ _0655_ _1870_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__o221ai_2
XFILLER_28_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput3 dmem_rdata_i[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_84_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3004_ _0647_ _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__and4_1
XFILLER_37_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4955_ clknet_leaf_3_clk_i _0135_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3906_ _0932_ _1774_ _1777_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__a21o_1
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4886_ clknet_leaf_14_clk_i _0066_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[70\]
+ sky130_fd_sc_hd__dfrtp_1
X_3837_ _0422_ _1679_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__or2_1
XFILLER_165_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3768_ _0424_ _1651_ _0780_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__a21o_1
XFILLER_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2719_ _0363_ _0369_ _0374_ i_decode_stage.reg_meta_o\[53\] VGND VGND VPWR VPWR _0643_
+ sky130_fd_sc_hd__a31oi_2
XFILLER_161_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3699_ _0345_ _0478_ _0501_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__a21o_1
XFILLER_106_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_397 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_164_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4740_ _2292_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4671_ i_decode_stage.fetch_state_i\[28\] _1929_ _2142_ VGND VGND VPWR VPWR _0229_
+ sky130_fd_sc_hd__a21o_1
XFILLER_147_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3622_ _1129_ _0583_ _1479_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__a21o_1
XFILLER_174_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3553_ _0858_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__xnor2_1
XFILLER_143_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3484_ _0656_ _0934_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__nand2_1
X_2504_ _0328_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__buf_6
XFILLER_142_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2435_ i_mem_slice_stage.mem_state_o\[40\] i_mem_slice_stage.mem_state_o\[1\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__mux2_1
XFILLER_103_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5223_ clknet_leaf_20_clk_i _0222_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[21\]
+ sky130_fd_sc_hd__dfrtp_1
X_5154_ clknet_leaf_10_clk_i net356 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[61\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4105_ i_decode_stage.decode_state_o\[242\] _1913_ _1914_ _1922_ i_decode_stage.decode_state_o\[243\]
+ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__a221o_2
XFILLER_84_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2366_ i_decode_stage.reg_meta_o\[43\] _0317_ _0318_ _0319_ VGND VGND VPWR VPWR _0320_
+ sky130_fd_sc_hd__nand4_2
XFILLER_57_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5085_ clknet_leaf_22_clk_i i_decode_stage.decode_state_o\[29\] net286 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[60\] sky130_fd_sc_hd__dfrtp_1
XFILLER_29_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4036_ _0391_ _0402_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__nand2_1
XFILLER_84_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4938_ clknet_leaf_16_clk_i _0118_ net292 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dfrtp_4
XFILLER_21_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4869_ clknet_leaf_22_clk_i _0049_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[53\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_153_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_283 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput170 net170 VGND VGND VPWR VPWR dmem_wdata_o[12] sky130_fd_sc_hd__buf_2
XFILLER_106_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput181 net181 VGND VGND VPWR VPWR dmem_wdata_o[22] sky130_fd_sc_hd__buf_2
Xoutput192 net192 VGND VGND VPWR VPWR dmem_wdata_o[3] sky130_fd_sc_hd__buf_2
XFILLER_88_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_156_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2984_ _0887_ _0889_ _0892_ _0894_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__o311a_1
XFILLER_166_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4723_ net216 i_decode_stage.fetch_state_i\[56\] _1927_ VGND VGND VPWR VPWR _2284_
+ sky130_fd_sc_hd__mux2_1
XFILLER_21_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_174_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4654_ _2254_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput50 imem_rdata_i[24] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_4
X_3605_ _1456_ _1496_ _0422_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__mux2_1
XFILLER_135_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput61 imem_rdata_i[5] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_4
Xinput72 rf_rs1_i[14] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_1
X_4585_ _2220_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
X_3536_ _0843_ _0939_ _1405_ _1430_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__o31a_1
Xinput83 rf_rs1_i[24] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_1
Xinput94 rf_rs1_i[5] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_1
XFILLER_143_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3467_ _0911_ _1355_ _1351_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__a21o_1
X_5206_ clknet_leaf_27_clk_i _0205_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_3398_ _1281_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__and2_1
XFILLER_97_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2418_ _0370_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_2
XFILLER_130_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5137_ clknet_leaf_7_clk_i net378 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[44\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_85_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2349_ i_decode_stage.decode_state_o\[125\] net276 VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__xor2_2
XFILLER_84_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5068_ clknet_leaf_28_clk_i i_decode_stage.decode_state_o\[12\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[43\] sky130_fd_sc_hd__dfrtp_1
X_4019_ net25 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[31\] sky130_fd_sc_hd__a21o_1
XFILLER_83_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_156_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4370_ net205 _2081_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__nor2_1
XFILLER_171_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3321_ _1129_ _1216_ _1217_ _1224_ _1074_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__o311a_1
XFILLER_98_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3252_ _1157_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__buf_4
XFILLER_112_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3183_ _1090_ _1094_ _0421_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__mux2_1
XFILLER_100_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_273 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2967_ i_decode_stage.decode_state_o\[46\] _0339_ _0751_ i_decode_stage.decode_state_o\[130\]
+ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__a22o_1
XFILLER_136_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2898_ i_decode_stage.decode_state_o\[60\] _0731_ _0733_ VGND VGND VPWR VPWR _0813_
+ sky130_fd_sc_hd__a21oi_1
X_4706_ _2275_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
X_4637_ i_decode_stage.fetch_state_i\[8\] _2067_ _2234_ VGND VGND VPWR VPWR _2246_
+ sky130_fd_sc_hd__mux2_1
XFILLER_135_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4568_ i_decode_stage.reg_meta_o\[55\] net69 _2207_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__mux2_1
X_3519_ _1328_ _1414_ _0523_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__mux2_1
XFILLER_104_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4499_ _2176_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3870_ _0525_ _1681_ _1747_ _1041_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__a211o_1
XFILLER_32_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2821_ _0532_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nor2_1
XPHY_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2752_ _0666_ _0672_ _0465_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__mux2_1
XFILLER_118_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4422_ _2125_ _0722_ _2126_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__and3b_1
X_2683_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[59\] VGND VGND VPWR VPWR _0611_
+ sky130_fd_sc_hd__o31a_1
XFILLER_141_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4353_ _2071_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__nor2_1
X_3304_ _1043_ _1207_ _0523_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__mux2_1
XFILLER_99_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4284_ net59 _1939_ _2023_ _1934_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__o211ai_1
X_3235_ _0660_ _1138_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__o21a_1
XFILLER_101_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3166_ _0345_ _0640_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3097_ _0754_ _0755_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_14_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_14_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_81_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_198 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3999_ net6 _1807_ _1813_ _1827_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[14\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_22_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_29_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_29_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_13_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_110 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_158_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3020_ _0386_ _0929_ _0930_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o31a_2
XFILLER_49_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4971_ clknet_leaf_2_clk_i _0151_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[32\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_64_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3922_ _1787_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__inv_2
X_3853_ _0345_ _0532_ _0557_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__a21o_1
XFILLER_20_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2804_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__clkbuf_16
XFILLER_158_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3784_ _0417_ _0563_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__nor2_1
XFILLER_20_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2735_ _0345_ _0650_ _0657_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
XFILLER_118_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2666_ i_mem_slice_stage.mem_state_o\[52\] i_mem_slice_stage.mem_state_o\[13\] _0453_
+ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__mux2_1
XFILLER_105_307 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4405_ net212 net213 _2101_ net214 VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__a31o_1
XFILLER_160_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2597_ net265 i_decode_stage.reg_meta_o\[74\] _0457_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__mux2_1
X_4336_ net228 _2055_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__or2_1
XFILLER_141_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4267_ i_decode_stage.decode_state_o\[130\] net52 _2012_ VGND VGND VPWR VPWR _2013_
+ sky130_fd_sc_hd__mux2_1
XFILLER_59_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3218_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__inv_1
XFILLER_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4198_ _1977_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_28_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3149_ _0343_ _0537_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand2_1
XFILLER_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_156_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_155_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2520_ i_mem_slice_stage.mem_state_o\[95\] _0452_ _0466_ _0455_ VGND VGND VPWR VPWR
+ net258 sky130_fd_sc_hd__a22o_1
XFILLER_60_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_142_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2451_ _0400_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__or4_1
XFILLER_5_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2382_ i_exec_stage.data_fwd_o\[1\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0335_
+ sky130_fd_sc_hd__and4_1
X_5170_ clknet_leaf_29_clk_i net406 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[77\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4121_ _1926_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__buf_12
XFILLER_110_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4052_ _0638_ _0829_ _0925_ _0630_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__o22a_1
Xinput4 dmem_rdata_i[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_110_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3003_ _0324_ _0326_ i_decode_stage.reg_meta_o\[15\] VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__o21ai_2
XFILLER_36_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4954_ clknet_leaf_3_clk_i _0134_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3905_ _0519_ _1774_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__nor2_1
X_4885_ clknet_leaf_17_clk_i _0065_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[69\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3836_ _1423_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__inv_2
XFILLER_118_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3767_ _0417_ _0470_ _0779_ _0413_ _1650_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__o221a_1
X_2718_ _0345_ _0633_ _0641_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__a21o_1
X_3698_ _0809_ _1584_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__xnor2_1
XFILLER_161_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2649_ _0338_ i_decode_stage.decode_state_o\[139\] i_decode_stage.decode_state_o\[43\]
+ _0339_ _2332_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__a221o_1
XFILLER_160_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5299_ clknet_leaf_24_clk_i _0298_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[33\]
+ sky130_fd_sc_hd__dfxtp_1
X_4319_ net152 _2042_ _2043_ _2046_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a22o_1
XFILLER_59_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_282 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4670_ i_decode_stage.fetch_state_i\[27\] _1929_ _2137_ VGND VGND VPWR VPWR _0228_
+ sky130_fd_sc_hd__a21o_1
X_3621_ _0966_ _1511_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__xnor2_1
X_3552_ _1409_ _1444_ _1445_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__a21o_1
X_2503_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__buf_12
XFILLER_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3483_ _1198_ _1379_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__a21bo_1
XFILLER_89_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_118 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2434_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__clkbuf_16
X_5222_ clknet_leaf_20_clk_i _0221_ net288 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_142_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5153_ clknet_leaf_7_clk_i net379 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[60\]
+ sky130_fd_sc_hd__dfrtp_1
X_2365_ i_exec_stage.data_fwd_o\[0\] i_exec_stage.data_fwd_o\[39\] VGND VGND VPWR
+ VPWR _0319_ sky130_fd_sc_hd__and2_1
XFILLER_111_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4104_ i_decode_stage.decode_state_o\[240\] _1921_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__xnor2_1
XFILLER_111_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5084_ clknet_leaf_20_clk_i i_decode_stage.decode_state_o\[28\] net288 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[59\] sky130_fd_sc_hd__dfrtp_1
X_4035_ _0578_ _0689_ _0701_ _0519_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__a22oi_1
XFILLER_84_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4937_ clknet_leaf_17_clk_i _0117_ net292 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dfrtp_4
XFILLER_166_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4868_ clknet_leaf_21_clk_i _0048_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[52\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_165_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3819_ _0662_ _1626_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__nand2_1
XFILLER_119_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4799_ i_exec_stage.data_fwd_o\[30\] net151 _1838_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__mux2_1
XFILLER_133_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput160 net160 VGND VGND VPWR VPWR dmem_addr_o[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput182 net182 VGND VGND VPWR VPWR dmem_wdata_o[23] sky130_fd_sc_hd__buf_2
XFILLER_121_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput171 net171 VGND VGND VPWR VPWR dmem_wdata_o[13] sky130_fd_sc_hd__buf_2
Xoutput193 net193 VGND VGND VPWR VPWR dmem_wdata_o[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_87_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2983_ _0589_ _0691_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__nand2_1
XTAP_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4722_ _2283_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput40 imem_rdata_i[15] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_4
X_4653_ i_decode_stage.fetch_state_i\[16\] _2093_ _2234_ VGND VGND VPWR VPWR _2254_
+ sky130_fd_sc_hd__mux2_1
XFILLER_174_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_163_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput51 imem_rdata_i[25] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_2
X_3604_ _0345_ _0622_ _1075_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__a21oi_1
Xinput62 imem_rdata_i[6] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_4
Xinput73 rf_rs1_i[15] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_1
X_4584_ i_decode_stage.reg_meta_o\[63\] net77 _2207_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__mux2_1
XFILLER_143_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3535_ _0430_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__nor2_1
Xinput84 rf_rs1_i[25] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
Xinput95 rf_rs1_i[6] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
XFILLER_143_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3466_ _0913_ _0921_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__and2_1
XFILLER_89_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2417_ i_fwd_unit.mem_stage_i\[0\] i_fwd_unit.mem_stage_i\[39\] VGND VGND VPWR VPWR
+ _0370_ sky130_fd_sc_hd__and2_1
X_5205_ clknet_leaf_27_clk_i _0204_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_3397_ _1193_ _1297_ _0523_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__mux2_1
XFILLER_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5136_ clknet_leaf_8_clk_i net385 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[43\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_322 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2348_ i_decode_stage.decode_state_o\[127\] net278 VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__xor2_2
XFILLER_29_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5067_ clknet_leaf_29_clk_i i_decode_stage.decode_state_o\[11\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[42\] sky130_fd_sc_hd__dfrtp_1
XFILLER_45_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4018_ net24 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[30\] sky130_fd_sc_hd__a21o_1
XFILLER_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3320_ _1219_ _1223_ _0709_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__mux2_1
XFILLER_140_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3251_ i_decode_stage.decode_state_o\[238\] i_decode_stage.decode_state_o\[239\]
+ _0408_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__or3_1
XFILLER_112_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3182_ _0344_ _0883_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a21o_1
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_285 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2966_ _0878_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_2
XFILLER_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2897_ i_exec_stage.data_fwd_o\[21\] _0726_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__o21ai_4
X_4705_ net206 i_decode_stage.fetch_state_i\[47\] _1927_ VGND VGND VPWR VPWR _2275_
+ sky130_fd_sc_hd__mux2_1
XFILLER_148_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4636_ _2245_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
XFILLER_151_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4567_ _2211_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
XFILLER_143_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3518_ _1370_ _1413_ _0422_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__mux2_1
XFILLER_104_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4498_ i_decode_stage.reg_meta_o\[21\] net105 _2012_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__mux2_1
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3449_ _0589_ _0594_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__nand2_1
XFILLER_104_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5119_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[22\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[22\] sky130_fd_sc_hd__dfrtp_1
XFILLER_94_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_77 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_327 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_428 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2820_ _2333_ _0730_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__a21o_1
XFILLER_157_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2751_ _0346_ i_decode_stage.decode_state_o\[132\] _0347_ _0671_ VGND VGND VPWR VPWR
+ _0672_ sky130_fd_sc_hd__a22oi_4
XFILLER_157_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2682_ _0345_ _0603_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a21o_1
XFILLER_172_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4421_ net215 net216 _2112_ net217 VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__a31o_1
XFILLER_172_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4352_ net231 _2065_ net201 VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__a21oi_1
X_3303_ _1205_ _1206_ _0421_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__mux2_1
XFILLER_125_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4283_ _2022_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__inv_2
XFILLER_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3234_ _0540_ _1094_ _1139_ _0662_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a211o_1
XFILLER_86_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3165_ _0465_ _0603_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__and2_1
XFILLER_82_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3096_ _0773_ _1006_ _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3998_ net5 _1807_ _1813_ _1825_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[13\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_22_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2949_ _0386_ _0861_ _0862_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__o31ai_4
XFILLER_136_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4619_ i_decode_stage.decode_state_o\[123\] net44 _2234_ VGND VGND VPWR VPWR _2238_
+ sky130_fd_sc_hd__mux2_1
XFILLER_145_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_158_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4970_ clknet_leaf_2_clk_i _0150_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3921_ _0336_ _0969_ _0601_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__mux2_1
XFILLER_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3852_ _0738_ _0744_ _0430_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__a21oi_1
XFILLER_165_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2803_ net33 net66 _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__and3_1
XFILLER_20_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3783_ _1359_ _1648_ _1665_ _1350_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_118_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2734_ _0465_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__and2_1
XFILLER_117_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2665_ _0448_ _0591_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__a21bo_1
XFILLER_118_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2596_ i_mem_slice_stage.mem_state_o\[101\] _0452_ _0533_ _0455_ VGND VGND VPWR VPWR
+ net265 sky130_fd_sc_hd__a22o_1
X_4404_ net213 net214 _2105_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__and3_1
XFILLER_160_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4335_ net228 _2055_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__nand2_1
XFILLER_113_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4266_ _0722_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__buf_12
XFILLER_86_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3217_ _1051_ _1070_ _0540_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__mux2_1
XFILLER_67_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4197_ i_decode_stage.decode_state_o\[42\] i_decode_stage.fetch_state_i\[34\] _1840_
+ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__mux2_1
X_3148_ _1054_ _1059_ _0523_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__mux2_1
XFILLER_28_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3079_ _0989_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__or2_2
XFILLER_70_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_102 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_13_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_13_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_114_105 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2450_ i_exec_stage.data_fwd_o\[2\] VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__inv_1
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2381_ i_decode_stage.reg_meta_o\[43\] _0317_ _0318_ _0319_ VGND VGND VPWR VPWR _0334_
+ sky130_fd_sc_hd__and4_1
XFILLER_96_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4120_ i_decode_stage.decode_state_o\[4\] _1929_ _1935_ VGND VGND VPWR VPWR _0002_
+ sky130_fd_sc_hd__a21o_1
Xclkbuf_leaf_28_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_28_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_110_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4051_ _0386_ _0929_ _0930_ _0931_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__o31ai_2
Xinput5 dmem_rdata_i[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_110_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3002_ _0324_ _0326_ _0645_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__or3_1
XFILLER_49_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4953_ clknet_leaf_1_clk_i _0133_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3904_ _0519_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__inv_2
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4884_ clknet_leaf_17_clk_i _0064_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[68\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_60_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3835_ _0424_ _1714_ _1015_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3766_ _1198_ _0779_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__nand2_1
XFILLER_20_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2717_ _0465_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__and2_1
XFILLER_118_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3697_ _0816_ _1566_ _0815_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__a21o_1
XFILLER_10_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2648_ _0578_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkinv_2
XFILLER_160_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2579_ i_exec_stage.data_fwd_o\[3\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0518_
+ sky130_fd_sc_hd__and4_1
X_5298_ clknet_leaf_6_clk_i _0297_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[32\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_99_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4318_ net222 _2045_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__or2_1
X_4249_ _2003_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_219 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3620_ _0958_ _0975_ _0995_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__o21ba_1
X_3551_ _0832_ _0841_ _0842_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__o21a_1
XFILLER_155_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_425 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2502_ _0449_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__clkbuf_4
XFILLER_170_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3482_ _0417_ _0656_ _1379_ _0413_ _0424_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__o221a_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2433_ _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__and3_1
X_5221_ clknet_leaf_20_clk_i _0220_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_142_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5152_ clknet_leaf_11_clk_i net342 net296 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[59\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2364_ i_decode_stage.decode_state_o\[124\] i_exec_stage.data_fwd_o\[33\] VGND VGND
+ VPWR VPWR _0318_ sky130_fd_sc_hd__or2b_1
XFILLER_111_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4103_ _1902_ _1852_ _1879_ _1920_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__or4_1
XFILLER_111_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5083_ clknet_leaf_22_clk_i i_decode_stage.decode_state_o\[27\] net286 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[58\] sky130_fd_sc_hd__dfrtp_1
X_4034_ _1841_ _1842_ _1847_ _1851_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__or4_1
XFILLER_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4936_ clknet_leaf_17_clk_i _0116_ net292 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dfrtp_4
XFILLER_21_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4867_ clknet_leaf_22_clk_i _0047_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[51\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_166_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3818_ _1661_ _1698_ _0422_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__mux2_1
XFILLER_119_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4798_ _2321_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
XFILLER_134_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3749_ _0411_ _1619_ _1622_ _1633_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__a211o_4
XFILLER_21_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_161_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput150 net150 VGND VGND VPWR VPWR dmem_addr_o[28] sky130_fd_sc_hd__buf_2
Xoutput161 net161 VGND VGND VPWR VPWR dmem_addr_o[9] sky130_fd_sc_hd__buf_2
XFILLER_161_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput183 net183 VGND VGND VPWR VPWR dmem_wdata_o[24] sky130_fd_sc_hd__buf_2
Xoutput172 net172 VGND VGND VPWR VPWR dmem_wdata_o[14] sky130_fd_sc_hd__clkbuf_4
Xoutput194 net194 VGND VGND VPWR VPWR dmem_wdata_o[5] sky130_fd_sc_hd__buf_2
XFILLER_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2982_ _0525_ _0893_ _0887_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__or3_1
XTAP_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4721_ net215 i_decode_stage.fetch_state_i\[55\] _1927_ VGND VGND VPWR VPWR _2283_
+ sky130_fd_sc_hd__mux2_1
XTAP_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4652_ _2253_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
Xinput30 dmem_rdata_i[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
X_3603_ _0958_ _0975_ _1494_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__o21a_1
Xinput52 imem_rdata_i[26] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_2
Xinput41 imem_rdata_i[16] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_4
Xinput63 imem_rdata_i[7] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_2
XFILLER_116_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4583_ _2219_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
XFILLER_155_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3534_ _0939_ _1405_ _0843_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__o21a_1
Xinput85 rf_rs1_i[26] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_1
Xinput74 rf_rs1_i[16] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_1
Xinput96 rf_rs1_i[7] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_1
XFILLER_143_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3465_ _1344_ _1345_ _1363_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__a21o_2
XFILLER_89_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2416_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__buf_2
X_5204_ clknet_leaf_21_clk_i _0203_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_3396_ _0540_ _1295_ _1296_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__o21ai_1
X_5135_ clknet_leaf_8_clk_i net384 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[42\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2347_ i_decode_stage.decode_state_o\[128\] net279 VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__xor2_2
XFILLER_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5066_ clknet_leaf_0_clk_i net353 net281 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[41\]
+ sky130_fd_sc_hd__dfrtp_1
X_4017_ net22 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[29\] sky130_fd_sc_hd__a21o_1
XFILLER_53_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4919_ clknet_leaf_21_clk_i _0099_ net286 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dfrtp_4
XFILLER_165_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_2_2__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_2__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
XFILLER_119_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_161_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_156_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_156_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3250_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__buf_6
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3181_ _0343_ _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__nor2_1
XFILLER_79_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2965_ _0877_ i_exec_stage.data_fwd_o\[7\] _0439_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux2_1
X_4704_ _2274_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
XFILLER_148_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2896_ i_decode_stage.reg_meta_o\[26\] _0727_ _0386_ _0810_ VGND VGND VPWR VPWR _0811_
+ sky130_fd_sc_hd__a211o_1
XFILLER_163_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4635_ i_decode_stage.fetch_state_i\[7\] _2063_ _2234_ VGND VGND VPWR VPWR _2245_
+ sky130_fd_sc_hd__mux2_1
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4566_ i_decode_stage.reg_meta_o\[54\] net68 _2207_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__mux2_1
XFILLER_150_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3517_ _0344_ _0640_ _1082_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__a21oi_1
XFILLER_104_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4497_ _2175_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_3448_ _0944_ _1317_ _0920_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__o21ai_1
XFILLER_103_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3379_ _0582_ _0712_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__nor2_2
XFILLER_112_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5118_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[21\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5049_ clknet_leaf_6_clk_i net139 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_166_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2750_ _0358_ _0668_ _0669_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__o31a_2
XFILLER_172_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2681_ _0465_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__and2_1
XFILLER_172_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4420_ net216 net217 _2117_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__and3_1
XFILLER_132_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4351_ net231 net201 _2065_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__and3_1
X_3302_ _0691_ _0695_ _0344_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__mux2_1
X_4282_ _1930_ _1938_ _2020_ _2021_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__a211o_1
X_3233_ _0540_ _1097_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__nor2_1
XFILLER_101_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3164_ _0345_ _0608_ _1075_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3095_ _0563_ _0770_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__and2b_1
XFILLER_82_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3997_ net4 _1807_ _1813_ _1823_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[12\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_13_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2948_ i_exec_stage.data_fwd_o\[6\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0863_
+ sky130_fd_sc_hd__or4_1
XFILLER_22_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2879_ i_exec_stage.data_fwd_o\[23\] _0726_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__o21ai_4
XFILLER_89_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4618_ _2237_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
XFILLER_135_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4549_ i_decode_stage.reg_meta_o\[46\] net89 _2179_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__mux2_1
XFILLER_150_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_166_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3920_ _1785_ _1106_ _1786_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__o21ai_1
XFILLER_17_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3851_ _0738_ _0744_ _1723_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__or3_1
X_3782_ _0712_ _1664_ _1129_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__o21ai_1
X_2802_ _0439_ _0358_ i_exec_stage.data_fwd_o\[38\] VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__o21ai_2
XFILLER_20_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2733_ _0346_ i_decode_stage.decode_state_o\[134\] _0347_ _0655_ VGND VGND VPWR VPWR
+ _0656_ sky130_fd_sc_hd__a22oi_4
XFILLER_173_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2664_ i_decode_stage.decode_state_o\[239\] _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nor2_4
X_2595_ i_mem_slice_stage.mem_state_o\[69\] i_mem_slice_stage.mem_state_o\[30\] _0453_
+ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__mux2_2
XFILLER_133_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4403_ net213 _1929_ _2111_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a21o_1
X_4334_ net157 _2047_ _2048_ _2057_ _2058_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__o221a_1
XFILLER_141_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4265_ _2011_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
XFILLER_86_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3216_ _0540_ _1056_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__o21ai_1
XFILLER_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4196_ _1976_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_28_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3147_ _1056_ _1058_ _0421_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__mux2_1
XFILLER_67_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3078_ _0507_ _0988_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__and2_1
XTAP_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_9_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_9_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_78_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_155_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_117 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2380_ _0312_ _0313_ _0314_ _0315_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__and4_1
XFILLER_69_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4050_ _0726_ _0914_ _0915_ _0916_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__a31o_1
Xinput6 dmem_rdata_i[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_3001_ _0911_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__nor2_2
XFILLER_49_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4952_ clknet_leaf_1_clk_i _0132_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_33_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3903_ _0917_ _1774_ _1776_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__a21o_1
X_4883_ clknet_leaf_14_clk_i _0063_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
X_3834_ _0417_ _0556_ _1014_ _0415_ _1713_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__o221a_1
XFILLER_60_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3765_ _1129_ _1324_ _1647_ _1648_ _1331_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__a32o_1
XFILLER_118_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3696_ _0411_ _1567_ _1580_ _1583_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__a211o_4
X_2716_ _0450_ _0638_ _0639_ _0492_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_173_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2647_ _0322_ _0574_ _0576_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__a31oi_4
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2578_ _0324_ _0326_ net264 VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__or3_1
XFILLER_160_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5297_ clknet_leaf_6_clk_i _0296_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_4317_ _2044_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__clkbuf_4
XFILLER_142_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4248_ i_decode_stage.decode_state_o\[67\] i_decode_stage.fetch_state_i\[59\] _1982_
+ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__mux2_1
XFILLER_68_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4179_ i_decode_stage.fetch_state_i\[25\] i_decode_stage.decode_state_o\[33\] _1967_
+ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__mux2_1
XFILLER_28_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3550_ _0841_ _0842_ _0834_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__and3b_1
XFILLER_155_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2501_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__or2_1
XFILLER_115_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3481_ _0656_ _0934_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__nor2_1
X_5220_ clknet_leaf_20_clk_i _0219_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_142_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2432_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__buf_6
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_170_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5151_ clknet_leaf_6_clk_i net377 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[58\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2363_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[124\] VGND VGND
+ VPWR VPWR _0317_ sky130_fd_sc_hd__or2b_1
XFILLER_111_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4102_ _1916_ _1917_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__or3_1
X_5082_ clknet_leaf_20_clk_i i_decode_stage.decode_state_o\[26\] net286 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[57\] sky130_fd_sc_hd__dfrtp_1
XFILLER_110_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4033_ _1848_ _1849_ _1850_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__or3b_1
XFILLER_110_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4935_ clknet_leaf_17_clk_i _0115_ net292 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dfrtp_4
XFILLER_33_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4866_ clknet_leaf_26_clk_i _0046_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[50\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_165_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3817_ _1697_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__inv_2
XFILLER_119_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4797_ i_exec_stage.data_fwd_o\[29\] net150 _1838_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__mux2_1
XFILLER_20_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3748_ _1129_ _1628_ _1631_ _0790_ _1632_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__a221o_1
XFILLER_21_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3679_ _0817_ _1566_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__xnor2_1
XFILLER_97_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput151 net151 VGND VGND VPWR VPWR dmem_addr_o[29] sky130_fd_sc_hd__buf_2
Xoutput140 net140 VGND VGND VPWR VPWR dmem_addr_o[18] sky130_fd_sc_hd__buf_2
XFILLER_88_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput184 net184 VGND VGND VPWR VPWR dmem_wdata_o[25] sky130_fd_sc_hd__buf_2
XFILLER_121_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput173 net173 VGND VGND VPWR VPWR dmem_wdata_o[15] sky130_fd_sc_hd__clkbuf_4
Xoutput195 net195 VGND VGND VPWR VPWR dmem_wdata_o[6] sky130_fd_sc_hd__clkbuf_4
Xoutput162 net162 VGND VGND VPWR VPWR dmem_be_o[0] sky130_fd_sc_hd__clkbuf_4
X_5349_ net42 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_1
XFILLER_102_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_12_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_12_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_71_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_27_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_27_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_168_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2981_ _0703_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__inv_2
XTAP_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4720_ _2282_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
X_4651_ i_decode_stage.fetch_state_i\[15\] _2089_ _2234_ VGND VGND VPWR VPWR _2253_
+ sky130_fd_sc_hd__mux2_1
XFILLER_147_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput20 dmem_rdata_i[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput31 dmem_rdata_i[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_3602_ _0958_ _0975_ _0430_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__a21oi_1
XFILLER_162_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput53 imem_rdata_i[27] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_2
Xinput42 imem_rdata_i[17] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_4
Xinput64 imem_rdata_i[8] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_2
XFILLER_116_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4582_ i_decode_stage.reg_meta_o\[62\] net76 _2207_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__mux2_1
XFILLER_171_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3533_ _0843_ _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__xnor2_1
Xinput86 rf_rs1_i[27] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_1
Xinput75 rf_rs1_i[17] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_1
Xinput97 rf_rs1_i[8] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_1
X_3464_ _1156_ _1346_ _1347_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__a31o_1
XFILLER_131_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5203_ clknet_leaf_23_clk_i _0202_ net289 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dfrtp_4
X_2415_ _0364_ _0365_ _0366_ _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and4_1
X_3395_ _0421_ _1239_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__or2_1
X_5134_ clknet_leaf_8_clk_i net373 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[41\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2346_ _2334_ _2335_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__nor2_8
XFILLER_57_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5065_ clknet_leaf_23_clk_i i_decode_stage.decode_state_o\[41\] net289 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[40\] sky130_fd_sc_hd__dfrtp_1
X_4016_ net21 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[28\] sky130_fd_sc_hd__a21o_1
XFILLER_16_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4918_ clknet_leaf_26_clk_i _0098_ net282 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dfrtp_4
XFILLER_166_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4849_ clknet_leaf_18_clk_i _0029_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[33\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_370 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3180_ _0346_ i_decode_stage.decode_state_o\[129\] _0347_ _1091_ VGND VGND VPWR VPWR
+ _1092_ sky130_fd_sc_hd__a22o_1
XFILLER_79_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2964_ i_decode_stage.reg_meta_o\[12\] net270 _0441_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__mux2_1
XFILLER_148_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4703_ net205 i_decode_stage.fetch_state_i\[46\] _1927_ VGND VGND VPWR VPWR _2274_
+ sky130_fd_sc_hd__mux2_1
XFILLER_50_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2895_ _2336_ _2341_ net254 VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__and3_1
XFILLER_147_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4634_ _2244_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
X_4565_ _2210_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
XFILLER_143_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3516_ _0590_ _0712_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__nor2_1
XFILLER_171_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4496_ i_decode_stage.reg_meta_o\[20\] net104 _2012_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__mux2_1
X_3447_ _0920_ _0944_ _1317_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__or3_1
XFILLER_104_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3378_ _0662_ _1136_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__a21oi_1
XFILLER_58_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5117_ clknet_leaf_11_clk_i i_mem_slice_stage.pre_data\[20\] net296 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[20\] sky130_fd_sc_hd__dfrtp_1
XFILLER_112_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5048_ clknet_leaf_7_clk_i net138 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_2828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_460 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_368 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2680_ _0450_ _0606_ _0492_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_172_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4350_ net161 _2047_ _2048_ _2069_ _2070_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__o221a_1
XFILLER_153_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3301_ _1152_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__inv_1
XFILLER_98_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4281_ net59 _1937_ _1938_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__and3_1
XFILLER_4_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3232_ _1081_ _1090_ _0422_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__mux2_1
XFILLER_140_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3163_ _0465_ _0617_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__and2_1
X_3094_ _0470_ _0778_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__and2b_1
XFILLER_82_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3996_ net3 _1807_ _1813_ _1821_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[11\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_148_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2947_ _0324_ _0326_ i_decode_stage.reg_meta_o\[11\] VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__o21a_1
XFILLER_13_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2878_ i_decode_stage.reg_meta_o\[28\] _0727_ _0386_ _0792_ VGND VGND VPWR VPWR _0793_
+ sky130_fd_sc_hd__a211o_1
X_4617_ i_decode_stage.decode_state_o\[122\] net43 _2234_ VGND VGND VPWR VPWR _2237_
+ sky130_fd_sc_hd__mux2_1
XFILLER_117_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4548_ _2201_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
XFILLER_144_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4479_ _2166_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
XFILLER_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_161_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_135_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3850_ _0738_ _1727_ _1158_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__a21oi_1
X_3781_ _1519_ _1663_ _0590_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__mux2_1
X_2801_ _0719_ VGND VGND VPWR VPWR i_exec_stage.alu_out\[1\] sky130_fd_sc_hd__buf_4
X_2732_ _0358_ _0652_ _0653_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__o31a_2
XFILLER_173_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2663_ i_decode_stage.decode_state_o\[238\] _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__nand2_2
XFILLER_117_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_172_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2594_ _0451_ _0530_ _0462_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__a2bb2o_4
X_4402_ net143 _1924_ _2042_ _2110_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__o22a_1
XFILLER_141_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4333_ net227 _1840_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__or2_1
XFILLER_101_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4264_ i_decode_stage.decode_state_o\[129\] net51 _1982_ VGND VGND VPWR VPWR _2011_
+ sky130_fd_sc_hd__mux2_1
X_3215_ _0422_ _1053_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__or2_1
XFILLER_141_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4195_ i_decode_stage.decode_state_o\[41\] i_decode_stage.fetch_state_i\[1\] _1840_
+ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__mux2_1
X_3146_ _0345_ _0622_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a21oi_1
XFILLER_95_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3077_ _0507_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__nor2_1
XFILLER_94_282 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_444 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3979_ net27 _1809_ _1824_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[4\] sky130_fd_sc_hd__a21o_1
XFILLER_149_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_23 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_190 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 dmem_rdata_i[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_3000_ _0672_ _0910_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__and2_1
XFILLER_77_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4951_ clknet_leaf_1_clk_i _0131_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[12\]
+ sky130_fd_sc_hd__dfrtp_1
X_3902_ _0391_ _1774_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__nor2_1
X_4882_ clknet_leaf_14_clk_i _0062_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[66\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3833_ _1198_ _1014_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__nand2_1
XFILLER_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3764_ _1501_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__inv_2
XFILLER_20_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3695_ _0817_ _1581_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__o21a_1
X_2715_ i_decode_stage.decode_state_o\[0\] _0493_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nand2_1
XFILLER_173_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2646_ i_exec_stage.data_fwd_o\[4\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0577_
+ sky130_fd_sc_hd__and4_1
XFILLER_145_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2577_ i_mem_slice_stage.mem_state_o\[73\] _0328_ _0516_ _0330_ VGND VGND VPWR VPWR
+ net264 sky130_fd_sc_hd__a22o_1
XFILLER_102_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5296_ clknet_leaf_4_clk_i _0295_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_4316_ _0722_ _1924_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__and2_1
X_4247_ _2002_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4178_ _1926_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__buf_12
XFILLER_28_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3129_ _1040_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__buf_4
XFILLER_28_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_167_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2500_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__clkbuf_16
X_3480_ _0935_ _0946_ _1347_ _0430_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__a31o_1
XFILLER_170_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2431_ i_decode_stage.decode_state_o\[233\] i_decode_stage.decode_state_o\[232\]
+ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__or2_1
XFILLER_142_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5150_ clknet_leaf_5_clk_i net387 net296 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[57\]
+ sky130_fd_sc_hd__dfrtp_1
X_2362_ _0312_ _0313_ _0314_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__nand4_2
XFILLER_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4101_ _1855_ _1863_ _1918_ _1854_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__or4b_1
XFILLER_57_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5081_ clknet_leaf_21_clk_i net354 net286 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[56\]
+ sky130_fd_sc_hd__dfrtp_1
X_4032_ _0481_ _0794_ _0803_ _0475_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__o22a_1
XFILLER_80_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4934_ clknet_leaf_17_clk_i _0114_ net292 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dfrtp_4
XFILLER_52_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4865_ clknet_leaf_27_clk_i _0045_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[49\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_165_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3816_ _0345_ _0551_ _0569_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_leaf_8_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_8_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4796_ _2320_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
XFILLER_165_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3747_ _1299_ _1313_ _0448_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__o21a_1
XFILLER_20_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_173_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3678_ _1492_ _1563_ _1565_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__o21ai_2
XFILLER_134_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput141 net141 VGND VGND VPWR VPWR dmem_addr_o[19] sky130_fd_sc_hd__buf_2
X_2629_ _0346_ i_decode_stage.decode_state_o\[129\] VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__or2b_1
Xoutput152 net152 VGND VGND VPWR VPWR dmem_addr_o[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_153_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput185 net185 VGND VGND VPWR VPWR dmem_wdata_o[26] sky130_fd_sc_hd__clkbuf_4
Xoutput174 net174 VGND VGND VPWR VPWR dmem_wdata_o[16] sky130_fd_sc_hd__clkbuf_4
Xoutput163 net163 VGND VGND VPWR VPWR dmem_be_o[1] sky130_fd_sc_hd__clkbuf_4
X_5348_ net41 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_1
Xoutput196 net196 VGND VGND VPWR VPWR dmem_wdata_o[7] sky130_fd_sc_hd__buf_2
XFILLER_101_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5279_ clknet_leaf_25_clk_i _0278_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_102_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_143_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2980_ _0890_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__nor2_2
XTAP_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4650_ _2252_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput21 dmem_rdata_i[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput10 dmem_rdata_i[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_3601_ _0975_ _1492_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__xnor2_1
Xinput54 imem_rdata_i[28] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_2
Xinput43 imem_rdata_i[18] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_4
Xinput32 dmem_rdata_i[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
X_4581_ _2218_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_155_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput65 imem_rdata_i[9] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_2
XFILLER_116_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3532_ _0834_ _1409_ _0832_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__a21o_1
Xinput87 rf_rs1_i[28] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
Xinput76 rf_rs1_i[18] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_1
Xinput98 rf_rs1_i[9] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
XFILLER_116_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3463_ _0448_ _1350_ _1354_ _1355_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__a221o_1
XFILLER_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5202_ clknet_leaf_15_clk_i _0201_ net289 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dfrtp_4
XFILLER_69_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2414_ net277 i_decode_stage.decode_state_o\[121\] VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__or2b_1
X_3394_ _0666_ _0677_ _0465_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__mux2_1
X_5133_ clknet_leaf_8_clk_i i_exec_stage.exec_state_o\[8\] net294 VGND VGND VPWR VPWR
+ i_mem_slice_stage.mem_state_o\[40\] sky130_fd_sc_hd__dfrtp_1
XFILLER_97_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2345_ i_decode_stage.decode_state_o\[126\] net277 VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__xor2_4
XFILLER_57_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5064_ clknet_leaf_23_clk_i i_decode_stage.decode_state_o\[40\] net289 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[39\] sky130_fd_sc_hd__dfrtp_1
X_4015_ net20 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[27\] sky130_fd_sc_hd__a21o_1
XFILLER_65_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4917_ clknet_leaf_27_clk_i _0097_ net282 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dfrtp_4
XFILLER_166_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4848_ clknet_leaf_15_clk_i _0028_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[32\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4779_ i_exec_stage.data_fwd_o\[20\] net141 _1839_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__mux2_1
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_196 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2963_ _0666_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__xnor2_2
XFILLER_50_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4702_ _2273_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2894_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__buf_2
XFILLER_163_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4633_ i_decode_stage.fetch_state_i\[6\] _2061_ _2234_ VGND VGND VPWR VPWR _2244_
+ sky130_fd_sc_hd__mux2_1
X_4564_ i_decode_stage.reg_meta_o\[53\] net98 _2207_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__mux2_1
XFILLER_116_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3515_ _0834_ _1409_ _0411_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__o21a_1
XFILLER_143_363 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_11_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_11_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_131_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4495_ _2174_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
X_3446_ _0920_ _1343_ _1158_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__a21oi_1
X_3377_ _0660_ _1138_ _1088_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__a21o_1
XFILLER_97_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5116_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[19\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_26_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_26_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_5047_ clknet_leaf_6_clk_i net137 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_169_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3300_ _0448_ _0712_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__nor2_4
XFILLER_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4280_ net61 _2019_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__nor2_1
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3231_ _1134_ _1136_ _0660_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__mux2_1
XFILLER_101_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3162_ i_decode_stage.decode_state_o\[236\] _0418_ i_decode_stage.decode_state_o\[238\]
+ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__and3_2
XFILLER_66_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3093_ _0753_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__inv_2
XFILLER_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3995_ net2 _1807_ _1813_ _1819_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[10\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_50_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2946_ _2336_ _2341_ net269 VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__and3_1
XFILLER_13_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2877_ _2336_ _2341_ net256 VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__and3_1
XFILLER_148_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4616_ _2236_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XFILLER_163_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4547_ i_decode_stage.reg_meta_o\[45\] net78 _2179_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__mux2_1
XFILLER_131_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4478_ i_decode_stage.reg_meta_o\[11\] net126 _2012_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__mux2_1
X_3429_ _0662_ _1328_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__or2_1
XFILLER_104_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_161_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_56 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3780_ _1587_ _1662_ _0523_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__mux2_1
X_2800_ _0434_ _0711_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__or3_1
XFILLER_32_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2731_ i_exec_stage.data_fwd_o\[11\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0654_
+ sky130_fd_sc_hd__or4_1
XFILLER_9_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2662_ i_decode_stage.decode_state_o\[236\] _0418_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__and2_2
X_4401_ net213 _2105_ _2109_ _1927_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__a211oi_1
XFILLER_172_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2593_ _0346_ i_decode_stage.decode_state_o\[133\] VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__or2b_1
XFILLER_125_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4332_ _2055_ _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__nor2_1
XFILLER_141_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4263_ _2010_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
XFILLER_115_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3214_ _0662_ _0546_ _1115_ _1119_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a31o_1
XFILLER_113_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4194_ _1975_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
X_3145_ _0465_ _0512_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__and2_1
XFILLER_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3076_ _2333_ _0986_ _0987_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a21o_1
XFILLER_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_456 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3978_ net13 _1815_ _1823_ _1810_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__a22o_1
XFILLER_11_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2929_ _2336_ _2341_ net248 VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__and3_1
XFILLER_149_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput8 dmem_rdata_i[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_283 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4950_ clknet_leaf_3_clk_i _0130_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_64_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3901_ _1775_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__inv_2
X_4881_ clknet_leaf_14_clk_i _0061_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[65\]
+ sky130_fd_sc_hd__dfrtp_1
X_3832_ _1016_ _1710_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__or2_1
XFILLER_146_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3763_ _0707_ _1645_ _1646_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__o21ai_1
X_3694_ _0817_ _1581_ _0430_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__a21oi_1
X_2714_ _0358_ _0635_ _0636_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__o31a_2
XFILLER_173_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2645_ _0324_ _0326_ net267 VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__or3_1
XFILLER_173_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2576_ i_mem_slice_stage.mem_state_o\[41\] i_mem_slice_stage.mem_state_o\[2\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__mux2_2
X_4315_ net222 _1840_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__nand2_1
XFILLER_141_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5295_ clknet_leaf_5_clk_i _0294_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_4246_ i_decode_stage.decode_state_o\[66\] i_decode_stage.fetch_state_i\[58\] _1982_
+ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__mux2_1
XFILLER_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4177_ _1966_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_3128_ _0582_ _0712_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__or2_1
XFILLER_83_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3059_ _2333_ _0969_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__a21o_1
XFILLER_82_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_403 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_406 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2430_ _0347_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__nand2_2
XFILLER_170_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2361_ i_decode_stage.decode_state_o\[127\] i_exec_stage.data_fwd_o\[36\] VGND VGND
+ VPWR VPWR _0315_ sky130_fd_sc_hd__or2b_1
X_4100_ _0519_ _0701_ _1867_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__o21bai_1
XFILLER_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5080_ clknet_leaf_29_clk_i i_decode_stage.decode_state_o\[24\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[55\] sky130_fd_sc_hd__dfrtp_1
X_4031_ _0620_ _0969_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__nor2_1
XFILLER_2_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4933_ clknet_leaf_18_clk_i _0113_ net291 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dfrtp_4
XFILLER_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4864_ clknet_leaf_26_clk_i _0044_ net283 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[48\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_165_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3815_ _0709_ _1398_ _1695_ _0754_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__a22o_1
X_4795_ i_exec_stage.data_fwd_o\[28\] net149 _1838_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__mux2_1
XFILLER_20_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3746_ _0424_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__nand2_1
XFILLER_20_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3677_ _0990_ _1564_ _0981_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__o21ba_1
Xoutput142 net142 VGND VGND VPWR VPWR dmem_addr_o[20] sky130_fd_sc_hd__buf_2
X_2628_ i_exec_stage.data_fwd_o\[26\] _0560_ _0460_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__mux2_2
X_2559_ _0465_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__and2_1
XFILLER_142_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput186 net186 VGND VGND VPWR VPWR dmem_wdata_o[27] sky130_fd_sc_hd__clkbuf_4
Xoutput175 net175 VGND VGND VPWR VPWR dmem_wdata_o[17] sky130_fd_sc_hd__clkbuf_4
Xoutput164 net164 VGND VGND VPWR VPWR dmem_be_o[2] sky130_fd_sc_hd__clkbuf_4
Xoutput153 net153 VGND VGND VPWR VPWR dmem_addr_o[30] sky130_fd_sc_hd__buf_2
XFILLER_102_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5347_ net40 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_1
XFILLER_153_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput197 net197 VGND VGND VPWR VPWR dmem_wdata_o[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_102_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5278_ clknet_leaf_25_clk_i _0277_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_4229_ _1993_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
XFILLER_75_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_214 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput22 dmem_rdata_i[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
Xinput11 dmem_rdata_i[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3600_ _1488_ _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__nor2_2
X_4580_ i_decode_stage.reg_meta_o\[61\] net75 _2207_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__mux2_1
XFILLER_174_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput55 imem_rdata_i[29] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_2
XFILLER_162_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput44 imem_rdata_i[19] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_4
X_3531_ _1404_ _1406_ _1426_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__a21o_4
Xinput33 imem_gnt_i VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_4
XFILLER_171_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput66 imem_rvalid_i VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_4
XFILLER_116_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput88 rf_rs1_i[29] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
Xinput77 rf_rs1_i[19] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_1
XFILLER_115_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3462_ _0448_ _1360_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__nor2_1
Xinput99 rf_rs2_i[0] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
XFILLER_131_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3393_ _0876_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__xnor2_1
X_5201_ clknet_leaf_23_clk_i net371 net289 VGND VGND VPWR VPWR i_fwd_unit.mem_stage_i\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_2413_ net275 i_decode_stage.decode_state_o\[119\] VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__or2b_1
XFILLER_130_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5132_ clknet_leaf_8_clk_i i_exec_stage.exec_state_o\[7\] net294 VGND VGND VPWR VPWR
+ i_mem_slice_stage.mem_state_o\[39\] sky130_fd_sc_hd__dfrtp_1
X_2344_ i_decode_stage.decode_state_o\[124\] net275 VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__xor2_4
XFILLER_97_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5063_ clknet_leaf_10_clk_i net154 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[38\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4014_ net19 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[26\] sky130_fd_sc_hd__a21o_1
XFILLER_65_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4916_ clknet_leaf_26_clk_i _0096_ net282 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dfrtp_4
X_4847_ clknet_leaf_16_clk_i _0027_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4778_ _2311_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
XFILLER_5_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3729_ _1566_ _1613_ _1614_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__a21o_1
XFILLER_164_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_7_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_7_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_94_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2962_ _2333_ net196 _0874_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a21oi_2
XFILLER_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4701_ net204 i_decode_stage.fetch_state_i\[45\] _1927_ VGND VGND VPWR VPWR _2273_
+ sky130_fd_sc_hd__mux2_1
XTAP_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2893_ _0806_ _0807_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__or2b_1
X_4632_ _2243_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_163_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4563_ _2209_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3514_ _0834_ _1409_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__nand2_1
X_4494_ i_decode_stage.reg_meta_o\[19\] net103 _2012_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__mux2_1
XFILLER_171_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3445_ _0920_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__or2_1
XFILLER_134_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3376_ _0590_ _1277_ _1274_ _0594_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__o211a_1
XFILLER_131_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5115_ clknet_leaf_11_clk_i i_mem_slice_stage.pre_data\[18\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_111_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5046_ clknet_leaf_7_clk_i net136 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_27_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xcore_298 VGND VGND VPWR VPWR core_298/HI dmem_addr_o[0] sky130_fd_sc_hd__conb_1
XFILLER_31_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3230_ _0540_ _1078_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__a21oi_1
XFILLER_113_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3161_ _1060_ _1072_ _0582_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__mux2_1
XFILLER_79_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3092_ _0765_ _0783_ _0825_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__or4bb_2
XFILLER_63_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3994_ net32 _1807_ _1813_ _1817_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[9\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_50_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2945_ _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__inv_2
XFILLER_148_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2876_ _0789_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__and2b_1
XFILLER_148_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4615_ i_decode_stage.decode_state_o\[121\] net42 _2234_ VGND VGND VPWR VPWR _2236_
+ sky130_fd_sc_hd__mux2_1
X_4546_ _2200_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
XFILLER_150_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4477_ _2165_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
X_3428_ _1283_ _1327_ _0422_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__mux2_1
XFILLER_131_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3359_ _0899_ _1234_ _0881_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__o21a_1
XFILLER_98_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_161_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5029_ clknet_leaf_15_clk_i i_decode_stage.decode_state_o\[5\] net290 VGND VGND VPWR
+ VPWR i_exec_stage.exec_state_o\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_2638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_68 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_73 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_10_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_10_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_72_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2730_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[54\] VGND VGND VPWR VPWR _0653_
+ sky130_fd_sc_hd__o31a_1
X_2661_ _0588_ _0524_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_25_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_25_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_172_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4400_ net213 _2105_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__nor2_1
XFILLER_9_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2592_ i_exec_stage.data_fwd_o\[30\] _0529_ _0460_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__mux2_1
XFILLER_172_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4331_ net227 _2051_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__nor2_1
XFILLER_141_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4262_ net39 i_decode_stage.decode_state_o\[118\] _1967_ VGND VGND VPWR VPWR _2010_
+ sky130_fd_sc_hd__mux2_1
XFILLER_125_194 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3213_ _0662_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__nor2_1
XFILLER_101_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4193_ i_decode_stage.decode_state_o\[40\] i_decode_stage.fetch_state_i\[0\] _1840_
+ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__mux2_1
XFILLER_67_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3144_ _0344_ _0507_ _1055_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__a21oi_1
XFILLER_95_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3075_ i_decode_stage.decode_state_o\[58\] _0731_ _0733_ VGND VGND VPWR VPWR _0987_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3977_ net4 net21 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__mux2_1
XFILLER_50_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2928_ _0841_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nand2b_2
XFILLER_164_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2859_ _2336_ _2341_ net258 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and3_1
XFILLER_40_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4529_ i_decode_stage.reg_meta_o\[36\] net122 _2179_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__mux2_1
XFILLER_132_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_167_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput9 dmem_rdata_i[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
XFILLER_76_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3900_ _0336_ _0908_ _1774_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux2_1
X_4880_ clknet_leaf_16_clk_i _0060_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[64\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_32_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3831_ _1016_ _1710_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nand2_1
XFILLER_32_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3762_ _0590_ _1498_ _0712_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__o21ba_1
XFILLER_146_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3693_ _0958_ _0993_ _1001_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__o21bai_1
X_2713_ i_exec_stage.data_fwd_o\[13\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0637_
+ sky130_fd_sc_hd__or4_1
X_2644_ i_mem_slice_stage.mem_state_o\[74\] _0328_ _0575_ _0330_ VGND VGND VPWR VPWR
+ net267 sky130_fd_sc_hd__a22o_2
XFILLER_161_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2575_ _2336_ _2341_ i_decode_stage.reg_meta_o\[8\] VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a21o_1
XFILLER_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4314_ _1926_ _1924_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__nor2_8
XFILLER_141_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5294_ clknet_leaf_4_clk_i _0293_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_102_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4245_ _2001_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
XFILLER_142_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4176_ i_decode_stage.fetch_state_i\[24\] i_decode_stage.decode_state_o\[32\] _1936_
+ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__mux2_1
XFILLER_19_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3127_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[237\]
+ _1037_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__a31o_1
XFILLER_83_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3058_ i_decode_stage.decode_state_o\[56\] _0731_ _0733_ VGND VGND VPWR VPWR _0970_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_70_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_415 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_164_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_160_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_232 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2360_ i_decode_stage.decode_state_o\[125\] i_exec_stage.data_fwd_o\[34\] VGND VGND
+ VPWR VPWR _0314_ sky130_fd_sc_hd__or2b_1
XFILLER_69_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4030_ _0475_ _0803_ _0812_ _0498_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__a22o_1
XFILLER_2_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4932_ clknet_leaf_16_clk_i _0112_ net292 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dfrtp_4
XFILLER_80_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4863_ clknet_leaf_22_clk_i _0043_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[47\]
+ sky130_fd_sc_hd__dfrtp_1
X_3814_ _0415_ _1693_ _1694_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__o21ai_1
X_4794_ _2319_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3745_ _0417_ _0464_ _0789_ _0413_ _1629_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__o221a_1
XFILLER_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3676_ _0989_ _1526_ _0982_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__o21ai_1
Xoutput143 net143 VGND VGND VPWR VPWR dmem_addr_o[21] sky130_fd_sc_hd__clkbuf_4
Xoutput132 net132 VGND VGND VPWR VPWR dmem_addr_o[10] sky130_fd_sc_hd__clkbuf_4
X_2627_ net259 i_decode_stage.reg_meta_o\[69\] _0457_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__mux2_1
Xoutput176 net176 VGND VGND VPWR VPWR dmem_wdata_o[18] sky130_fd_sc_hd__buf_2
Xoutput165 net165 VGND VGND VPWR VPWR dmem_be_o[3] sky130_fd_sc_hd__clkbuf_4
Xoutput154 net154 VGND VGND VPWR VPWR dmem_addr_o[31] sky130_fd_sc_hd__clkbuf_4
XFILLER_102_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2558_ _0451_ _0498_ _0462_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_88_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput187 net187 VGND VGND VPWR VPWR dmem_wdata_o[28] sky130_fd_sc_hd__clkbuf_4
Xoutput198 net198 VGND VGND VPWR VPWR dmem_wdata_o[9] sky130_fd_sc_hd__buf_2
X_2489_ _0435_ _0436_ _0437_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__and4_2
X_5277_ clknet_leaf_24_clk_i _0276_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_102_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4228_ i_decode_stage.decode_state_o\[57\] i_decode_stage.fetch_state_i\[49\] _1982_
+ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__mux2_1
XFILLER_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4159_ _1957_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_83_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_213 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_270 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput12 dmem_rdata_i[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XFILLER_30_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput23 dmem_rdata_i[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput45 imem_rdata_i[1] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput34 imem_rdata_i[0] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
X_3530_ _1410_ _1411_ _1425_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__a21o_1
XFILLER_171_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput56 imem_rdata_i[2] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
Xinput89 rf_rs1_i[2] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_1
Xinput78 rf_rs1_i[1] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
Xinput67 rf_rs1_i[0] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
XFILLER_170_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3461_ _0661_ _1088_ _0524_ _1287_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__o221a_1
XFILLER_116_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_170_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3392_ _1270_ _1264_ _1267_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__a21o_1
X_5200_ clknet_leaf_26_clk_i net338 net286 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dfrtp_4
X_2412_ i_decode_stage.decode_state_o\[119\] net275 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__or2b_1
XFILLER_124_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2343_ _2332_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__buf_12
X_5131_ clknet_leaf_23_clk_i net398 net289 VGND VGND VPWR VPWR i_fwd_unit.mem_stage_i\[39\]
+ sky130_fd_sc_hd__dfrtp_1
X_5062_ clknet_leaf_10_clk_i net153 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[37\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_96_154 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4013_ net18 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[25\] sky130_fd_sc_hd__a21o_1
XFILLER_85_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4915_ clknet_leaf_27_clk_i _0095_ net282 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dfrtp_4
XFILLER_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4846_ clknet_leaf_19_clk_i _0026_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4777_ i_exec_stage.data_fwd_o\[19\] net140 _1839_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__mux2_1
XFILLER_162_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3728_ _0806_ _0815_ _0807_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__o21a_1
XFILLER_113_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3659_ _0983_ _0998_ _1530_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__or3_1
XFILLER_164_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_25 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2961_ i_decode_stage.decode_state_o\[47\] _0731_ _0751_ i_decode_stage.decode_state_o\[131\]
+ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a22o_1
XFILLER_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4700_ _2272_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
XTAP_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2892_ _0478_ _0805_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand2_1
XFILLER_8_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4631_ i_decode_stage.fetch_state_i\[5\] _2057_ _2234_ VGND VGND VPWR VPWR _2243_
+ sky130_fd_sc_hd__mux2_1
XFILLER_147_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4562_ i_decode_stage.reg_meta_o\[52\] net97 _2207_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__mux2_1
XFILLER_171_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3513_ _0928_ _0935_ _1340_ _1364_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__a41o_1
X_4493_ _2173_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
XFILLER_131_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3444_ _0913_ _1340_ _0911_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__a21oi_1
XFILLER_171_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3375_ _0662_ _1115_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__nor2_1
XFILLER_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5114_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[17\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_97_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5045_ clknet_leaf_8_clk_i net135 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4829_ clknet_leaf_29_clk_i _0009_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_147_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_12 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xcore_299 VGND VGND VPWR VPWR core_299/HI dmem_addr_o[1] sky130_fd_sc_hd__conb_1
XFILLER_31_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3160_ _1066_ _1071_ _0523_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__mux2_1
XFILLER_79_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3091_ _0958_ _0993_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__o21ai_2
Xhold1 i_exec_stage.reg_meta_o\[4\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_55_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3993_ net31 _1829_ _1813_ _1811_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[8\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_148_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2944_ _0834_ _0843_ _0852_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__nand4b_1
XFILLER_50_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2875_ _0464_ _0788_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nand2_1
XFILLER_31_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4614_ _2235_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XFILLER_163_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4545_ i_decode_stage.reg_meta_o\[44\] net67 _2179_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__mux2_1
XFILLER_132_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4476_ i_decode_stage.reg_meta_o\[10\] net125 _2012_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__mux2_1
X_3427_ _0345_ _0672_ _1089_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__a21oi_1
X_3358_ _1260_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_161_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3289_ _0660_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__nand2_1
XFILLER_100_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5028_ clknet_leaf_11_clk_i i_decode_stage.decode_state_o\[118\] net296 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_2639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_6_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_6_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_21_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2660_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__clkbuf_16
XFILLER_9_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2591_ net263 i_decode_stage.reg_meta_o\[73\] _0457_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__mux2_1
XFILLER_160_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4330_ net222 net225 net226 net227 VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__and4_1
X_4261_ _2009_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
XFILLER_87_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3212_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__inv_2
X_4192_ _1974_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_39_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3143_ _0465_ _0495_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__and2_1
XFILLER_95_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3074_ i_exec_stage.data_fwd_o\[19\] _0726_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__o21ai_4
XFILLER_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3976_ net26 _1809_ _1822_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[3\] sky130_fd_sc_hd__a21o_1
XFILLER_11_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2927_ _0603_ _0840_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__nand2_1
XFILLER_50_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2858_ _0771_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__nand2b_2
XFILLER_164_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2789_ _0662_ _0685_ _0706_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a211o_1
XFILLER_117_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4528_ _2191_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
X_4459_ _2156_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XFILLER_172_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_390 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_469 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3830_ _1637_ _1708_ _1709_ _0754_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_32_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3761_ _1570_ _1644_ _0660_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_1
XFILLER_32_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2712_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[56\] VGND VGND VPWR VPWR _0636_
+ sky130_fd_sc_hd__o31a_1
XFILLER_146_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3692_ _1573_ _1574_ _1576_ _1579_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__a211o_1
XFILLER_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2643_ i_mem_slice_stage.mem_state_o\[42\] i_mem_slice_stage.mem_state_o\[3\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__mux2_1
X_2574_ _0502_ _0513_ _0421_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__mux2_1
X_4313_ i_decode_stage.decode_state_o\[243\] _1929_ _1940_ VGND VGND VPWR VPWR _0089_
+ sky130_fd_sc_hd__a21o_1
XFILLER_141_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5293_ clknet_leaf_6_clk_i _0292_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_87_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4244_ i_decode_stage.decode_state_o\[65\] i_decode_stage.fetch_state_i\[57\] _1982_
+ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__mux2_1
XFILLER_101_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4175_ _1965_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_67_241 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3126_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[237\]
+ _1033_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__and3b_1
XFILLER_82_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3057_ i_exec_stage.data_fwd_o\[17\] _0726_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__o21ai_4
XFILLER_70_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_17 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3959_ i_exec_stage.exec_state_o\[1\] i_exec_stage.exec_state_o\[8\] _1805_ _1808_
+ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__o31ai_4
XFILLER_51_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_427 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_24_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_24_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_73_244 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_167_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_246 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4931_ clknet_leaf_16_clk_i _0111_ net292 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dfrtp_4
XFILLER_80_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4862_ clknet_leaf_27_clk_i _0042_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[46\]
+ sky130_fd_sc_hd__dfrtp_1
X_3813_ _0417_ _0551_ _0755_ _0419_ _0424_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__o221a_1
XFILLER_33_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4793_ i_exec_stage.data_fwd_o\[27\] net148 _1838_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__mux2_1
X_3744_ _1198_ _0789_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__nand2_1
XFILLER_146_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3675_ _0983_ _0991_ _1525_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__or3_1
XFILLER_173_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2626_ i_mem_slice_stage.mem_state_o\[96\] _0452_ _0559_ _0455_ VGND VGND VPWR VPWR
+ net259 sky130_fd_sc_hd__a22o_1
Xoutput133 net133 VGND VGND VPWR VPWR dmem_addr_o[11] sky130_fd_sc_hd__clkbuf_4
Xoutput177 net177 VGND VGND VPWR VPWR dmem_wdata_o[19] sky130_fd_sc_hd__clkbuf_4
Xoutput144 net144 VGND VGND VPWR VPWR dmem_addr_o[22] sky130_fd_sc_hd__clkbuf_4
Xoutput155 net155 VGND VGND VPWR VPWR dmem_addr_o[3] sky130_fd_sc_hd__buf_2
X_2557_ _0346_ i_decode_stage.decode_state_o\[124\] VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__or2b_1
Xoutput166 net166 VGND VGND VPWR VPWR dmem_req_o sky130_fd_sc_hd__buf_2
Xoutput188 net188 VGND VGND VPWR VPWR dmem_wdata_o[29] sky130_fd_sc_hd__clkbuf_4
Xoutput199 net199 VGND VGND VPWR VPWR dmem_we_o sky130_fd_sc_hd__clkbuf_4
XFILLER_102_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2488_ i_decode_stage.reg_meta_o\[43\] _0313_ _0317_ _0318_ VGND VGND VPWR VPWR _0438_
+ sky130_fd_sc_hd__and4_1
X_5276_ clknet_leaf_25_clk_i _0275_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_102_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4227_ _1992_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
XFILLER_56_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4158_ i_decode_stage.fetch_state_i\[15\] i_decode_stage.decode_state_o\[23\] _1936_
+ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__mux2_1
X_3109_ i_decode_stage.decode_state_o\[70\] _0731_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nand2_1
X_4089_ _1900_ _1906_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__or2b_1
XFILLER_83_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_258 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput13 dmem_rdata_i[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
XFILLER_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput46 imem_rdata_i[20] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_4
Xinput24 dmem_rdata_i[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput35 imem_rdata_i[10] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_2
XFILLER_128_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput57 imem_rdata_i[30] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_2
XFILLER_143_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput79 rf_rs1_i[20] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_1
Xinput68 rf_rs1_i[10] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_1
XFILLER_170_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3460_ _0716_ _1326_ _1358_ _1041_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__o22a_1
XFILLER_170_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3391_ _1292_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_4
X_2411_ net278 i_decode_stage.decode_state_o\[122\] VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__or2b_1
XFILLER_96_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2342_ i_decode_stage.decode_state_o\[233\] i_decode_stage.decode_state_o\[232\]
+ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__nor2_2
X_5130_ clknet_leaf_3_clk_i i_exec_stage.exec_state_o\[5\] net284 VGND VGND VPWR VPWR
+ i_mem_slice_stage.mem_state_o\[37\] sky130_fd_sc_hd__dfrtp_1
X_5061_ clknet_leaf_9_clk_i net151 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[36\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_69_358 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4012_ net17 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[24\] sky130_fd_sc_hd__a21o_1
XFILLER_96_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4914_ clknet_leaf_27_clk_i _0094_ net282 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dfrtp_4
XFILLER_80_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4845_ clknet_leaf_22_clk_i _0025_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[29\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_32_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4776_ _2310_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
XFILLER_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3727_ _0809_ _0817_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__nor2_1
XFILLER_20_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3658_ _0998_ _1530_ _0983_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__o21ai_1
XFILLER_134_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_208 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2609_ _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__buf_4
X_3589_ _1199_ _0850_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__nand2_1
XFILLER_88_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5259_ clknet_leaf_18_clk_i _0258_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[57\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_57_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2960_ _0873_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__inv_2
XFILLER_62_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2891_ _0478_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nor2_1
XTAP_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4630_ _2242_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
XFILLER_163_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4561_ _2208_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3512_ _0950_ _1407_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__nand2_1
X_4492_ i_decode_stage.reg_meta_o\[18\] net102 _2012_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__mux2_1
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3443_ _1156_ _1319_ _1336_ _1342_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__a211o_4
XFILLER_171_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3374_ _0584_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__nor2_1
X_5113_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[16\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5044_ clknet_leaf_7_clk_i net134 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4828_ clknet_leaf_27_clk_i _0008_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4759_ i_exec_stage.data_fwd_o\[10\] net161 _1839_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__mux2_1
XFILLER_108_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold2 i_exec_stage.exec_state_o\[35\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkdlybuf4s25_1
X_3090_ _0824_ _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__nor2_1
XFILLER_94_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3992_ i_exec_stage.exec_state_o\[2\] _1832_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__nor2_4
XFILLER_23_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2943_ _0608_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__xnor2_4
XFILLER_16_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2874_ _0464_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nor2_1
XFILLER_30_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_163_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4613_ i_decode_stage.decode_state_o\[120\] net41 _2234_ VGND VGND VPWR VPWR _2235_
+ sky130_fd_sc_hd__mux2_1
X_4544_ i_decode_stage.reg_meta_o\[43\] _1928_ _1932_ _2199_ VGND VGND VPWR VPWR _0162_
+ sky130_fd_sc_hd__a22o_1
XFILLER_171_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4475_ _2164_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_3426_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__buf_2
X_3357_ _1232_ _1236_ _1249_ _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__or4_1
XFILLER_100_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3288_ _0422_ _0714_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__o21ai_1
X_5027_ clknet_leaf_11_clk_i i_decode_stage.decode_state_o\[117\] net296 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[1\] sky130_fd_sc_hd__dfrtp_4
XFILLER_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2590_ i_mem_slice_stage.mem_state_o\[100\] _0452_ _0528_ _0455_ VGND VGND VPWR VPWR
+ net263 sky130_fd_sc_hd__a22o_1
XFILLER_153_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4260_ net38 _0601_ _1967_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__mux2_1
XFILLER_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3211_ _0394_ _1064_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__o21a_1
X_4191_ i_decode_stage.fetch_state_i\[31\] i_decode_stage.decode_state_o\[39\] _1967_
+ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__mux2_1
X_3142_ _1051_ _1053_ _0421_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__mux2_1
XFILLER_140_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3073_ i_decode_stage.reg_meta_o\[24\] _0727_ _0386_ _0984_ VGND VGND VPWR VPWR _0985_
+ sky130_fd_sc_hd__a211o_1
XFILLER_55_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3975_ net11 _1815_ _1821_ _1810_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__a22o_1
XFILLER_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2926_ _0603_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nor2_1
XFILLER_10_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2857_ _0563_ _0770_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__nand2_1
XFILLER_164_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2788_ _0582_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__buf_8
XFILLER_117_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4527_ i_decode_stage.reg_meta_o\[35\] net120 _2179_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__mux2_1
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4458_ net63 i_decode_stage.decode_state_o\[147\] _1967_ VGND VGND VPWR VPWR _2156_
+ sky130_fd_sc_hd__mux2_1
X_3409_ _0901_ _1261_ _0876_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__o21ai_1
XFILLER_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4389_ net140 _2042_ _2045_ _2099_ _2100_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__a221o_1
XFILLER_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_328 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3760_ _0540_ _1602_ _1643_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__a21oi_1
XFILLER_32_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2711_ _0363_ _0369_ _0374_ net245 VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__and4_1
XFILLER_9_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3691_ _1199_ _1577_ _1578_ _0816_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__o31a_1
XFILLER_9_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2642_ _2336_ _2341_ i_decode_stage.reg_meta_o\[9\] VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__a21o_1
XFILLER_161_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2573_ _0507_ _0512_ _0343_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__mux2_1
XFILLER_114_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5292_ clknet_leaf_5_clk_i _0291_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_4312_ i_decode_stage.decode_state_o\[242\] _1928_ _2041_ net39 VGND VGND VPWR VPWR
+ _0088_ sky130_fd_sc_hd__a22o_1
XFILLER_113_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4243_ _2000_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
XFILLER_141_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_306 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4174_ i_decode_stage.fetch_state_i\[23\] i_decode_stage.decode_state_o\[31\] _1936_
+ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__mux2_1
XFILLER_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3125_ _1035_ _1025_ _0746_ _1034_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__o31a_1
Xclkbuf_leaf_5_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_5_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_95_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3056_ i_decode_stage.reg_meta_o\[22\] _0727_ _0386_ _0967_ VGND VGND VPWR VPWR _0968_
+ sky130_fd_sc_hd__a211o_1
XFILLER_24_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3958_ _1807_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__inv_2
XFILLER_167_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3889_ _1129_ _1476_ _1765_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__o21ai_1
XFILLER_109_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2909_ _0818_ _0819_ _0822_ _0800_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a221o_1
XFILLER_164_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_174_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_278 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4930_ clknet_leaf_19_clk_i _0110_ net288 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dfrtp_4
XFILLER_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4861_ clknet_leaf_27_clk_i _0041_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[45\]
+ sky130_fd_sc_hd__dfrtp_2
X_3812_ _0755_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__inv_2
X_4792_ _2318_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3743_ _1412_ _1475_ _1627_ _1281_ _1315_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__a221o_1
XFILLER_146_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3674_ _1156_ _1547_ _1548_ _1562_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__a31o_4
XFILLER_9_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2625_ i_mem_slice_stage.mem_state_o\[64\] i_mem_slice_stage.mem_state_o\[25\] _0453_
+ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__mux2_1
XFILLER_106_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput134 net134 VGND VGND VPWR VPWR dmem_addr_o[12] sky130_fd_sc_hd__clkbuf_4
Xoutput167 net167 VGND VGND VPWR VPWR dmem_wdata_o[0] sky130_fd_sc_hd__clkbuf_4
Xoutput145 net145 VGND VGND VPWR VPWR dmem_addr_o[23] sky130_fd_sc_hd__clkbuf_4
X_2556_ i_exec_stage.data_fwd_o\[21\] _0497_ _0460_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__mux2_1
Xoutput156 net156 VGND VGND VPWR VPWR dmem_addr_o[4] sky130_fd_sc_hd__buf_2
XFILLER_88_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput178 net178 VGND VGND VPWR VPWR dmem_wdata_o[1] sky130_fd_sc_hd__clkbuf_4
Xoutput189 net189 VGND VGND VPWR VPWR dmem_wdata_o[2] sky130_fd_sc_hd__buf_2
XFILLER_102_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2487_ _0308_ _0310_ _0314_ _0315_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__and4_1
X_5275_ clknet_leaf_25_clk_i _0274_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_141_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4226_ i_decode_stage.decode_state_o\[56\] i_decode_stage.fetch_state_i\[48\] _1982_
+ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__mux2_1
XFILLER_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4157_ _1956_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_110_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3108_ i_exec_stage.data_fwd_o\[31\] _0726_ _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__o21ai_4
XFILLER_56_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4088_ _1898_ _1893_ _1905_ _1899_ _1897_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__a221o_1
X_3039_ _0949_ _0927_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__or2_1
XFILLER_71_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_160_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput25 dmem_rdata_i[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput14 dmem_rdata_i[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput36 imem_rdata_i[11] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_2
XFILLER_128_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput58 imem_rdata_i[31] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_2
Xinput47 imem_rdata_i[21] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_4
XFILLER_128_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput69 rf_rs1_i[11] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_1
X_2410_ _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__buf_2
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3390_ _1263_ _1266_ _1271_ _1291_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__or4_1
XFILLER_170_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5060_ clknet_leaf_9_clk_i net150 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[35\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_69_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4011_ net16 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[23\] sky130_fd_sc_hd__a21o_1
XFILLER_28_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4913_ clknet_leaf_27_clk_i _0093_ net282 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dfrtp_4
XFILLER_33_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_270 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4844_ clknet_leaf_20_clk_i _0024_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_147_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4775_ i_exec_stage.data_fwd_o\[18\] net139 _1839_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__mux2_1
X_3726_ _1607_ _1610_ _1611_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__or3_1
XFILLER_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_23_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_23_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_173_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3657_ _0411_ _1528_ _1532_ _1546_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__a211o_4
XFILLER_164_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3588_ _1477_ _1478_ _1479_ _1480_ _0709_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__a32o_1
X_2608_ i_decode_stage.decode_state_o\[100\] _0543_ _0347_ VGND VGND VPWR VPWR _0544_
+ sky130_fd_sc_hd__mux2_1
XFILLER_142_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2539_ _0482_ _0346_ _0462_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__o21ai_1
XFILLER_88_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5258_ clknet_leaf_16_clk_i _0257_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[56\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_57_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5189_ clknet_leaf_18_clk_i net381 net291 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[96\]
+ sky130_fd_sc_hd__dfrtp_1
X_4209_ _1983_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_156_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2890_ _2333_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__a21o_1
XFILLER_15_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4560_ i_decode_stage.reg_meta_o\[51\] net96 _2207_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__mux2_1
XFILLER_8_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_397 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3511_ _1379_ _1365_ _1382_ _0951_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__o211ai_1
X_4491_ _2172_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
XFILLER_171_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3442_ _0913_ _1340_ _1341_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__o21a_1
XFILLER_170_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3373_ _0707_ _1272_ _1274_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__a21bo_1
XTAP_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_170_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5112_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[15\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_124_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5043_ clknet_leaf_8_clk_i net133 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4827_ clknet_leaf_29_clk_i _0007_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_138_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4758_ _2301_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3709_ _0809_ _1595_ _0430_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__a21oi_1
X_4689_ net229 i_decode_stage.fetch_state_i\[39\] _1967_ VGND VGND VPWR VPWR _2267_
+ sky130_fd_sc_hd__mux2_1
XFILLER_162_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold3 i_exec_stage.exec_state_o\[16\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_58_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3991_ net30 _1829_ _1813_ _1830_ _1833_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[7\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2942_ _2333_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a21o_2
XFILLER_16_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2873_ _2333_ _0786_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21o_1
XFILLER_31_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4612_ _0722_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__buf_12
XFILLER_163_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4543_ net62 net60 _1928_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__a21oi_1
XFILLER_144_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_334 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4474_ i_decode_stage.reg_meta_o\[9\] net124 _2012_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__mux2_1
X_3425_ _0589_ _0712_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__or2_1
X_3356_ _1254_ _1258_ _0448_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__o21a_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3287_ _0540_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__or2_1
XFILLER_100_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5026_ clknet_leaf_10_clk_i i_decode_stage.decode_state_o\[0\] net295 VGND VGND VPWR
+ VPWR i_exec_stage.exec_state_o\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_100_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_166_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3210_ _0394_ _1068_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__nand2_1
XFILLER_113_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4190_ _1973_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_3141_ _0345_ _0500_ _1052_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a21oi_1
XFILLER_121_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3072_ _2336_ _2341_ net251 VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__and3_1
XFILLER_36_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_107 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3974_ net3 net20 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__mux2_1
X_2925_ _2333_ _0838_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__a21o_1
X_2856_ _0563_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__nor2_1
XFILLER_164_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2787_ _0540_ _0696_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__a21oi_1
XFILLER_132_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4526_ _2190_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_172_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4457_ net154 _2042_ _2155_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__a21o_1
XFILLER_172_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3408_ _1129_ _1304_ _1307_ _1308_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__a22o_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4388_ net209 _1927_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__and2_1
X_3339_ _1041_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__nor2_1
XFILLER_86_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5009_ clknet_leaf_0_clk_i _0189_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[70\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_26_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_407 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2710_ i_mem_slice_stage.mem_state_o\[83\] _0328_ _0634_ _0330_ VGND VGND VPWR VPWR
+ net245 sky130_fd_sc_hd__a22o_1
XFILLER_158_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3690_ _0417_ _0500_ _0815_ _1198_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_145_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2641_ _0525_ _0539_ _0546_ _0572_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a31o_1
XFILLER_9_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2572_ _0451_ _0510_ _0492_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5291_ clknet_leaf_6_clk_i _0290_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_4311_ _2037_ _2041_ _1840_ i_decode_stage.decode_state_o\[241\] VGND VGND VPWR VPWR
+ _0087_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_114_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4242_ i_decode_stage.decode_state_o\[64\] i_decode_stage.fetch_state_i\[56\] _1982_
+ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__mux2_1
XFILLER_101_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4173_ _1964_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_3124_ _1026_ _1027_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a21o_1
XFILLER_95_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3055_ _2336_ _2341_ net249 VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__and3_1
XFILLER_55_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3957_ _1806_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__buf_2
X_2908_ _0464_ _0788_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__and2b_1
XFILLER_164_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3888_ _0707_ _1627_ _1763_ _1764_ _0448_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__a221o_1
XFILLER_164_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2839_ _0551_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__nand2_1
XFILLER_132_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4509_ i_decode_stage.reg_meta_o\[26\] net111 _2179_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__mux2_1
XFILLER_3_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4860_ clknet_leaf_26_clk_i _0040_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[44\]
+ sky130_fd_sc_hd__dfrtp_1
X_3811_ _1421_ _1393_ _0709_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_159_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4791_ i_exec_stage.data_fwd_o\[26\] net147 _1838_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__mux2_1
X_3742_ _1623_ _1626_ _0660_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux2_1
XFILLER_146_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3673_ _0411_ _1550_ _1551_ _1561_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__a211o_1
XFILLER_161_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2624_ _0343_ _0551_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a21o_1
XFILLER_133_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput168 net168 VGND VGND VPWR VPWR dmem_wdata_o[10] sky130_fd_sc_hd__clkbuf_4
Xoutput146 net146 VGND VGND VPWR VPWR dmem_addr_o[24] sky130_fd_sc_hd__buf_2
Xoutput135 net135 VGND VGND VPWR VPWR dmem_addr_o[13] sky130_fd_sc_hd__buf_2
Xoutput157 net157 VGND VGND VPWR VPWR dmem_addr_o[5] sky130_fd_sc_hd__clkbuf_4
X_2555_ net254 i_decode_stage.reg_meta_o\[64\] _0457_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__mux2_1
Xoutput179 net179 VGND VGND VPWR VPWR dmem_wdata_o[20] sky130_fd_sc_hd__clkbuf_4
XFILLER_99_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5274_ clknet_leaf_3_clk_i _0273_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_2486_ _0309_ _0312_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__and2_1
XFILLER_141_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4225_ _1991_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_4156_ i_decode_stage.fetch_state_i\[14\] i_decode_stage.decode_state_o\[22\] _1936_
+ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__mux2_1
XFILLER_110_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3107_ i_decode_stage.reg_meta_o\[36\] _0727_ _0386_ _1018_ VGND VGND VPWR VPWR _1019_
+ sky130_fd_sc_hd__a211o_1
XFILLER_56_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4087_ _1894_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__inv_2
XFILLER_56_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3038_ _0949_ _0927_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__nand2_1
XFILLER_62_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4989_ clknet_leaf_0_clk_i _0169_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[50\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_164_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_410 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput37 imem_rdata_i[12] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_4
Xinput15 dmem_rdata_i[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput26 dmem_rdata_i[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput48 imem_rdata_i[22] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_4
XFILLER_143_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput59 imem_rdata_i[3] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_4_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_4_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_170_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4010_ net15 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[22\] sky130_fd_sc_hd__a21o_1
XFILLER_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4912_ clknet_leaf_26_clk_i _0092_ net282 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dfrtp_4
XFILLER_80_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4843_ clknet_leaf_22_clk_i _0023_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_159_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4774_ _2309_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_147_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3725_ _1275_ _1479_ _1144_ _0799_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_146_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3656_ _1533_ _1536_ _1545_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__or3_1
XFILLER_161_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3587_ _1300_ _1312_ _0582_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__mux2_1
XFILLER_115_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2607_ i_exec_stage.data_fwd_o\[32\] _0542_ _0460_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__mux2_1
XFILLER_115_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2538_ i_decode_stage.decode_state_o\[126\] VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__inv_2
XFILLER_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5257_ clknet_leaf_16_clk_i _0256_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[55\]
+ sky130_fd_sc_hd__dfrtp_1
X_2469_ _0418_ i_decode_stage.decode_state_o\[239\] i_decode_stage.decode_state_o\[238\]
+ i_decode_stage.decode_state_o\[236\] VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__or4bb_4
XFILLER_102_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4208_ i_decode_stage.decode_state_o\[47\] i_decode_stage.fetch_state_i\[39\] _1982_
+ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__mux2_1
X_5188_ clknet_leaf_23_clk_i net404 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[95\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_56_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4139_ _1947_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_165_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3510_ _0430_ _1405_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__nor2_1
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4490_ i_decode_stage.reg_meta_o\[17\] net101 _2012_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__mux2_1
XFILLER_7_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3441_ _0913_ _1340_ _1158_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__a21oi_1
XFILLER_170_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3372_ _0582_ _1273_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__or2_1
XTAP_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5111_ clknet_leaf_7_clk_i i_mem_slice_stage.pre_data\[14\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_88_90 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5042_ clknet_leaf_5_clk_i net132 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4826_ clknet_leaf_30_clk_i _0006_ net281 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_147_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4757_ i_exec_stage.data_fwd_o\[9\] net160 _1839_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__mux2_1
XFILLER_147_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3708_ _0817_ _1581_ _0820_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__a21o_1
XFILLER_4_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4688_ _2266_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_3639_ _0966_ _1511_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__nor2_1
XFILLER_162_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold4 i_exec_stage.exec_state_o\[19\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_66_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_22_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_22_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3990_ _1832_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__inv_2
XFILLER_23_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2941_ i_decode_stage.decode_state_o\[54\] _0339_ _0733_ VGND VGND VPWR VPWR _0856_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_15_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2872_ i_decode_stage.decode_state_o\[63\] _0731_ _0733_ VGND VGND VPWR VPWR _0787_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_31_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4611_ _2233_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XFILLER_129_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4542_ _2198_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
XFILLER_171_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4473_ _2163_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
X_3424_ _1088_ _0584_ _1322_ _1323_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a22o_1
XFILLER_171_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3355_ _0584_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__nor2_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3286_ _0465_ _0691_ _0704_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__o21ai_1
XFILLER_100_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_425 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5025_ clknet_leaf_25_clk_i i_decode_stage.decode_state_o\[140\] net283 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4809_ i_exec_stage.data_fwd_o\[35\] i_decode_stage.decode_state_o\[138\] _1838_
+ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__mux2_1
XFILLER_154_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_158_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3140_ _0465_ _0478_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__and2_1
XFILLER_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3071_ _0981_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__nand2b_2
XFILLER_94_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3973_ net23 _1809_ _1820_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[2\] sky130_fd_sc_hd__a21o_1
X_2924_ i_decode_stage.decode_state_o\[53\] _0731_ _0733_ VGND VGND VPWR VPWR _0839_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_31_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2855_ _0384_ _0768_ _0769_ _0752_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__o211a_1
XFILLER_163_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2786_ _0422_ _0697_ _0704_ _0525_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a31o_1
X_4525_ i_decode_stage.reg_meta_o\[34\] net119 _2179_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__mux2_1
XFILLER_104_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4456_ net224 _1936_ _2045_ _2154_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__a22o_1
XFILLER_171_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3407_ _0666_ _0875_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__nand2_1
X_4387_ net209 _2095_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__xor2_1
X_3338_ _0715_ _1240_ _0523_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__mux2_1
XFILLER_112_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3269_ _0422_ _0684_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__or2_1
XTAP_2417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5008_ clknet_leaf_0_clk_i _0188_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[69\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_38_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_358 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_419 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2640_ _0523_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__and2_1
XFILLER_145_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_161_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2571_ i_decode_stage.decode_state_o\[121\] _0493_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
XFILLER_114_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5290_ clknet_leaf_2_clk_i _0289_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_4310_ i_decode_stage.decode_state_o\[240\] _1928_ _2041_ net37 VGND VGND VPWR VPWR
+ _0086_ sky130_fd_sc_hd__a22o_1
XFILLER_114_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4241_ _1999_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
XFILLER_113_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4172_ i_decode_stage.fetch_state_i\[22\] i_decode_stage.decode_state_o\[30\] _1936_
+ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__mux2_1
X_3123_ _1033_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nand2_2
XFILLER_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3054_ _0964_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nor2_2
XFILLER_95_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3956_ i_exec_stage.exec_state_o\[0\] i_exec_stage.exec_state_o\[1\] VGND VGND VPWR
+ VPWR _1806_ sky130_fd_sc_hd__and2b_1
XFILLER_50_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2907_ _0809_ _0820_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__a21o_1
X_3887_ _0662_ _1699_ _0707_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__a21oi_1
XFILLER_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2838_ _0384_ _0749_ _0750_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__o211a_1
XFILLER_164_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2769_ i_exec_stage.data_fwd_o\[4\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0688_
+ sky130_fd_sc_hd__or4_1
XFILLER_145_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4508_ _2181_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
XFILLER_132_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4439_ net218 net219 _2125_ net220 VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__a31o_1
XFILLER_132_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3810_ _0411_ _1689_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__and3_1
X_4790_ _2317_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
X_3741_ _0422_ _1586_ _1625_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__o21ai_1
XFILLER_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3672_ _1129_ _0594_ _1185_ _1557_ _1560_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__a311o_1
XFILLER_9_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2623_ _0465_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__and2_1
XFILLER_161_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2554_ i_mem_slice_stage.mem_state_o\[91\] _0452_ _0496_ _0455_ VGND VGND VPWR VPWR
+ net254 sky130_fd_sc_hd__a22o_1
XFILLER_114_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput147 net147 VGND VGND VPWR VPWR dmem_addr_o[25] sky130_fd_sc_hd__clkbuf_4
XFILLER_99_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput136 net136 VGND VGND VPWR VPWR dmem_addr_o[14] sky130_fd_sc_hd__clkbuf_4
Xoutput158 net158 VGND VGND VPWR VPWR dmem_addr_o[6] sky130_fd_sc_hd__buf_2
Xoutput169 net169 VGND VGND VPWR VPWR dmem_wdata_o[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_114_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5273_ clknet_leaf_2_clk_i _0272_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_2485_ i_exec_stage.data_fwd_o\[0\] i_exec_stage.data_fwd_o\[39\] _0307_ VGND VGND
+ VPWR VPWR _0435_ sky130_fd_sc_hd__and3_1
XFILLER_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4224_ i_decode_stage.decode_state_o\[55\] i_decode_stage.fetch_state_i\[47\] _1982_
+ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__mux2_1
X_4155_ _1955_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XFILLER_95_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3106_ _2336_ _2341_ net265 VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__and3_1
XFILLER_56_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4086_ _1891_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__inv_2
X_3037_ _0451_ _0630_ _0632_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__o21a_2
XFILLER_71_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4988_ clknet_leaf_0_clk_i _0168_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[49\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3939_ _1110_ _0786_ _1797_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__o21ai_1
XFILLER_164_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_422 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_159_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_159_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput16 dmem_rdata_i[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput27 dmem_rdata_i[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
XFILLER_128_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_167_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput49 imem_rdata_i[23] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_4
Xinput38 imem_rdata_i[13] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_4
XFILLER_128_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4911_ clknet_leaf_26_clk_i _0091_ net282 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dfrtp_4
XFILLER_46_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4842_ clknet_leaf_20_clk_i _0022_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[26\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_119_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4773_ i_exec_stage.data_fwd_o\[17\] net138 _1839_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__mux2_1
X_3724_ _1198_ _0797_ _1608_ _1199_ _1609_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__a221o_1
X_3655_ _1129_ _0594_ _1131_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__a31o_1
XFILLER_107_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2606_ net266 i_decode_stage.reg_meta_o\[75\] _0457_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__mux2_1
X_3586_ _0709_ _0545_ _1216_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__o21ai_4
XFILLER_115_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2537_ i_exec_stage.data_fwd_o\[23\] _0480_ _0460_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__mux2_2
X_2468_ i_decode_stage.decode_state_o\[237\] VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__inv_2
XFILLER_115_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5256_ clknet_leaf_20_clk_i _0255_ net288 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[54\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_102_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4207_ _0722_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__buf_12
XFILLER_96_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5187_ clknet_leaf_16_clk_i net355 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[94\]
+ sky130_fd_sc_hd__dfrtp_1
X_2399_ i_decode_stage.decode_state_o\[122\] _0348_ _0349_ _0350_ _0351_ VGND VGND
+ VPWR VPWR _0352_ sky130_fd_sc_hd__o2111ai_4
XFILLER_56_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4138_ i_decode_stage.fetch_state_i\[5\] i_decode_stage.decode_state_o\[13\] _1936_
+ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__mux2_1
X_4069_ _1845_ _1886_ _1846_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__o21a_1
XFILLER_56_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_272 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3440_ _0869_ _1228_ _1337_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__a31o_2
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3371_ _1123_ _1118_ _0525_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux2_1
XFILLER_112_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5110_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[13\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5041_ clknet_leaf_7_clk_i net161 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4825_ clknet_leaf_16_clk_i _0005_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_147_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4756_ _2300_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3707_ _1590_ _1592_ _1593_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__or3b_1
XFILLER_107_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4687_ net228 i_decode_stage.fetch_state_i\[38\] _1967_ VGND VGND VPWR VPWR _2266_
+ sky130_fd_sc_hd__mux2_1
XFILLER_162_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3638_ _0991_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__xor2_1
XFILLER_115_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3569_ _1198_ _1448_ _1454_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__a211o_1
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5239_ clknet_leaf_27_clk_i _0238_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[37\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_3_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_3_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XPHY_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold5 i_exec_stage.exec_state_o\[27\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_121_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2940_ i_exec_stage.data_fwd_o\[15\] _0322_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o21ai_4
XFILLER_15_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2871_ i_exec_stage.data_fwd_o\[24\] _0726_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__o21ai_4
X_4610_ i_decode_stage.decode_state_o\[119\] net40 _2207_ VGND VGND VPWR VPWR _2233_
+ sky130_fd_sc_hd__mux2_1
XFILLER_30_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4541_ i_decode_stage.decode_state_o\[128\] net50 _2179_ VGND VGND VPWR VPWR _2198_
+ sky130_fd_sc_hd__mux2_1
XFILLER_144_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4472_ i_decode_stage.reg_meta_o\[8\] net121 _2012_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__mux2_1
X_3423_ _0590_ _1072_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__nand2_1
XFILLER_116_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3354_ _0707_ _1256_ _1252_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__a21bo_1
XFILLER_112_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3285_ _1129_ _1172_ _1176_ _1186_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__a32o_1
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5024_ clknet_leaf_26_clk_i i_decode_stage.decode_state_o\[139\] net283 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4808_ _2326_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4739_ i_exec_stage.data_fwd_o\[0\] i_exec_stage.valid _1839_ VGND VGND VPWR VPWR
+ _2292_ sky130_fd_sc_hd__mux2_1
XFILLER_119_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3070_ _0495_ _0980_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__nand2_1
XFILLER_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3972_ net10 _1815_ _1819_ _1810_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__a22o_1
XFILLER_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2923_ _0726_ _0835_ _0836_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__a31o_1
X_2854_ i_decode_stage.decode_state_o\[65\] _0731_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nand2_1
XFILLER_31_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2785_ _0344_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__or2_1
X_4524_ _2189_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
XFILLER_171_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4455_ net224 _2151_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__xnor2_1
X_3406_ _0415_ _1305_ _1306_ _0424_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__o211ai_1
X_4386_ net139 _2042_ _2045_ _2097_ _2098_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a221o_1
X_3337_ _1191_ _1239_ _0421_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux2_1
XFILLER_131_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3268_ _0658_ _0673_ _0422_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__mux2_1
XFILLER_105_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3199_ _1107_ _1108_ i_exec_stage.alu_out\[1\] _1105_ VGND VGND VPWR VPWR net163
+ sky130_fd_sc_hd__a211oi_1
XFILLER_100_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5007_ clknet_leaf_1_clk_i _0187_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[68\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_21_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_21_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_150_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2570_ i_exec_stage.data_fwd_o\[18\] _0509_ _0460_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__mux2_2
XFILLER_126_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4240_ i_decode_stage.decode_state_o\[63\] i_decode_stage.fetch_state_i\[55\] _1982_
+ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__mux2_1
XFILLER_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4171_ _1963_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_122_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3122_ _0545_ _1032_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__nand2_1
XFILLER_68_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3053_ _0512_ _0963_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__and2_1
XFILLER_83_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3955_ i_exec_stage.exec_state_o\[0\] i_exec_stage.exec_state_o\[7\] VGND VGND VPWR
+ VPWR _1805_ sky130_fd_sc_hd__and2b_1
X_2906_ _0478_ _0805_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__and2b_1
XFILLER_50_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3886_ _0662_ _1177_ _1761_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__or4b_1
X_2837_ i_decode_stage.decode_state_o\[100\] _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nand2_2
X_2768_ _0363_ _0369_ _0374_ net267 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__and4_1
XFILLER_3_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2699_ _0610_ _0624_ _0540_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__mux2_1
XFILLER_132_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4507_ i_decode_stage.reg_meta_o\[25\] net109 _2179_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__mux2_1
XFILLER_132_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4438_ net219 net220 _2131_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__and3_1
XFILLER_132_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4369_ net205 _2081_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__and2_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3740_ _0540_ _1624_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__or2_1
XFILLER_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3671_ _1199_ _1558_ _1559_ _0982_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__o31a_1
XFILLER_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2622_ _0451_ _0554_ _0462_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_161_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2553_ i_mem_slice_stage.mem_state_o\[59\] i_mem_slice_stage.mem_state_o\[20\] _0453_
+ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__mux2_2
XFILLER_114_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput148 net148 VGND VGND VPWR VPWR dmem_addr_o[26] sky130_fd_sc_hd__buf_2
Xoutput137 net137 VGND VGND VPWR VPWR dmem_addr_o[15] sky130_fd_sc_hd__clkbuf_4
Xoutput159 net159 VGND VGND VPWR VPWR dmem_addr_o[7] sky130_fd_sc_hd__clkbuf_4
X_2484_ _0406_ _0407_ _0411_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a31o_1
X_5272_ clknet_leaf_4_clk_i _0271_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_114_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4223_ _1990_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_4154_ i_decode_stage.fetch_state_i\[13\] i_decode_stage.decode_state_o\[21\] _1936_
+ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__mux2_1
X_3105_ _1004_ _1012_ _1013_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a211o_1
X_4085_ _1885_ _1889_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__a21o_1
XFILLER_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3036_ _0656_ _0934_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__and2b_1
XFILLER_55_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4987_ clknet_leaf_30_clk_i _0167_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[48\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3938_ _1110_ net196 VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__nand2_1
XFILLER_164_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3869_ _0422_ _1718_ _1746_ _0523_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__o211a_1
XFILLER_164_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput17 dmem_rdata_i[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
Xinput28 dmem_rdata_i[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
Xinput39 imem_rdata_i[14] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_4
XFILLER_6_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_415 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4910_ clknet_leaf_21_clk_i _0090_ net286 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dfrtp_4
XTAP_2590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4841_ clknet_leaf_26_clk_i _0021_ net283 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[25\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_61_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4772_ _2308_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
XFILLER_146_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3723_ _0417_ _0484_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nor2_1
XFILLER_162_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3654_ _0709_ _1542_ _1543_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__a21oi_1
XFILLER_119_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2605_ i_mem_slice_stage.mem_state_o\[102\] _0452_ _0541_ _0455_ VGND VGND VPWR VPWR
+ net266 sky130_fd_sc_hd__a22o_1
XFILLER_161_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3585_ _0540_ _0525_ _0586_ _1348_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__or4_1
XFILLER_115_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_231 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2536_ net256 i_decode_stage.reg_meta_o\[66\] _0457_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__mux2_1
XFILLER_130_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2467_ i_decode_stage.decode_state_o\[237\] _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__nand2_8
X_5255_ clknet_leaf_22_clk_i _0254_ net288 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[53\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4206_ _1981_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_84_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2398_ i_decode_stage.decode_state_o\[121\] i_exec_stage.data_fwd_o\[35\] VGND VGND
+ VPWR VPWR _0351_ sky130_fd_sc_hd__or2b_1
XFILLER_68_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5186_ clknet_leaf_19_clk_i net363 net288 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[93\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_56_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4137_ _1946_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
X_4068_ _1843_ _1844_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__and2b_1
XFILLER_71_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3019_ i_exec_stage.data_fwd_o\[11\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0931_
+ sky130_fd_sc_hd__or4_1
XFILLER_24_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_164_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3370_ _0662_ _1115_ _1255_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__o21a_1
XFILLER_170_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5040_ clknet_leaf_5_clk_i net160 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_112_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4824_ clknet_leaf_15_clk_i _0004_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_119_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4755_ i_exec_stage.data_fwd_o\[8\] net159 _1839_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__mux2_1
X_3706_ _0415_ _0809_ _1257_ _1479_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__o22a_1
XFILLER_174_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_162_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4686_ _2265_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3637_ _1492_ _1525_ _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__o21ba_1
XFILLER_161_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3568_ _1144_ _1455_ _1459_ _1204_ _1461_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__a221o_1
XFILLER_115_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2519_ i_mem_slice_stage.mem_state_o\[63\] i_mem_slice_stage.mem_state_o\[24\] _0453_
+ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__mux2_1
X_3499_ _0589_ _0523_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nand2_2
XFILLER_130_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5238_ clknet_leaf_26_clk_i _0237_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[36\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_57_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5169_ clknet_leaf_29_clk_i net399 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[76\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_56_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 i_exec_stage.exec_state_o\[23\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_75_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2870_ i_decode_stage.reg_meta_o\[29\] _0727_ _0386_ _0784_ VGND VGND VPWR VPWR _0785_
+ sky130_fd_sc_hd__a211o_1
XFILLER_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_120 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4540_ _2197_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
XFILLER_128_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4471_ _2162_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
XFILLER_7_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3422_ _0582_ _0545_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__nand2_2
XFILLER_143_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3353_ _0525_ _0539_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__o21a_1
XFILLER_98_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3284_ _0448_ _1188_ _0584_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__a21o_1
XFILLER_112_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5023_ clknet_leaf_26_clk_i i_decode_stage.decode_state_o\[138\] net283 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4807_ i_exec_stage.data_fwd_o\[34\] i_decode_stage.decode_state_o\[137\] _1838_
+ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__mux2_1
XFILLER_22_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2999_ _0672_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__nor2_2
XFILLER_108_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4738_ _2291_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4669_ i_decode_stage.fetch_state_i\[26\] _1929_ _2133_ VGND VGND VPWR VPWR _0227_
+ sky130_fd_sc_hd__a21o_1
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_166_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3971_ net2 net19 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__mux2_1
XFILLER_90_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2922_ i_exec_stage.data_fwd_o\[14\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0837_
+ sky130_fd_sc_hd__and4b_1
XFILLER_149_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2853_ i_exec_stage.data_fwd_o\[26\] _0726_ _0767_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__o21ai_4
XFILLER_31_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2784_ _0450_ _0701_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__o21a_2
XFILLER_156_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4523_ i_decode_stage.reg_meta_o\[33\] net118 _2179_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__mux2_1
XFILLER_8_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_2_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_2_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_171_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4454_ _2149_ _2153_ net223 _1929_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__a2bb2o_1
X_3405_ _1198_ _1305_ _0666_ _0417_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_113_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4385_ net208 _1927_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__and2_1
X_3336_ _0683_ _0883_ _0465_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__mux2_1
XFILLER_86_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_100_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3267_ _0590_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__or2_1
XFILLER_100_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5006_ clknet_leaf_1_clk_i _0186_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3198_ i_exec_stage.alu_out\[0\] _1106_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__or2_1
XFILLER_39_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_91 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4170_ i_decode_stage.fetch_state_i\[21\] i_decode_stage.decode_state_o\[29\] _1936_
+ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__mux2_1
XFILLER_122_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3121_ _0545_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__or2_1
XFILLER_110_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3052_ _0512_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nor2_2
XFILLER_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3954_ _1110_ _1030_ _1785_ _1112_ _1786_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__o221ai_2
XFILLER_23_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3885_ _0345_ _0540_ _0537_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__or3_1
X_2905_ _0500_ _0814_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__and2b_1
X_2836_ _2333_ _0339_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__nor2_4
XFILLER_31_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2767_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[47\] VGND VGND VPWR VPWR _0686_
+ sky130_fd_sc_hd__o31a_1
XFILLER_145_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2698_ _0344_ _0617_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a21o_1
XFILLER_144_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4506_ _2180_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
XFILLER_2_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4437_ net150 _1924_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__or2_1
XFILLER_132_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4368_ net135 _2047_ _2048_ _2083_ _2084_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__o221a_1
X_3319_ _1220_ _1221_ _1222_ _0590_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__o22a_1
X_4299_ i_decode_stage.decode_state_o\[236\] _1840_ _2034_ VGND VGND VPWR VPWR _0082_
+ sky130_fd_sc_hd__o21a_1
XFILLER_112_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_158_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3670_ _0417_ _0495_ _0981_ _1198_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_173_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2621_ _0346_ i_decode_stage.decode_state_o\[132\] VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or2b_1
XFILLER_127_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2552_ _0451_ _0490_ _0492_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__a2bb2o_4
Xoutput149 net149 VGND VGND VPWR VPWR dmem_addr_o[27] sky130_fd_sc_hd__clkbuf_4
XFILLER_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput138 net138 VGND VGND VPWR VPWR dmem_addr_o[16] sky130_fd_sc_hd__clkbuf_4
X_5271_ clknet_leaf_3_clk_i _0270_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_142_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2483_ _0405_ _0415_ _0426_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__o211ai_1
XFILLER_114_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4222_ i_decode_stage.decode_state_o\[54\] i_decode_stage.fetch_state_i\[46\] _1982_
+ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__mux2_1
XFILLER_101_129 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4153_ _1954_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_3104_ _1014_ _1015_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nor2_2
X_4084_ _1892_ _1894_ _1896_ _1901_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__or4_1
XFILLER_95_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3035_ _0920_ _0944_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a21bo_1
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_290 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_20_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_20_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4986_ clknet_leaf_30_clk_i _0166_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[47\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3937_ _1796_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_1
XFILLER_137_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3868_ _0345_ _0537_ _1063_ _0540_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__a211o_1
XFILLER_164_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3799_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__inv_2
X_2819_ i_decode_stage.decode_state_o\[69\] _0731_ _0733_ VGND VGND VPWR VPWR _0734_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_11_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_216 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput18 dmem_rdata_i[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput29 dmem_rdata_i[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XFILLER_109_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_273 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_427 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_388 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4840_ clknet_leaf_29_clk_i _0020_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_2591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4771_ i_exec_stage.data_fwd_o\[16\] net137 _1839_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__mux2_1
XFILLER_159_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3722_ _0484_ _0796_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__nand2_1
XFILLER_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3653_ _1041_ _1154_ _0713_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__o21a_1
XFILLER_161_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2604_ i_mem_slice_stage.mem_state_o\[70\] i_mem_slice_stage.mem_state_o\[31\] _0453_
+ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__mux2_2
XFILLER_161_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3584_ _0709_ _0594_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nand2_1
XFILLER_115_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2535_ i_mem_slice_stage.mem_state_o\[93\] _0452_ _0479_ _0455_ VGND VGND VPWR VPWR
+ net256 sky130_fd_sc_hd__a22o_1
XFILLER_130_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2466_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[238\]
+ i_decode_stage.decode_state_o\[239\] VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__and3_4
X_5254_ clknet_leaf_20_clk_i _0253_ net288 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[52\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5185_ clknet_leaf_22_clk_i net405 net286 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[92\]
+ sky130_fd_sc_hd__dfrtp_1
X_4205_ i_decode_stage.decode_state_o\[46\] i_decode_stage.fetch_state_i\[38\] _1840_
+ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__mux2_1
X_2397_ i_exec_stage.data_fwd_o\[35\] i_decode_stage.decode_state_o\[121\] VGND VGND
+ VPWR VPWR _0350_ sky130_fd_sc_hd__or2b_1
X_4136_ i_decode_stage.fetch_state_i\[4\] i_decode_stage.decode_state_o\[12\] _1936_
+ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__mux2_1
XFILLER_56_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4067_ _1852_ _1884_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__or2_1
XFILLER_56_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3018_ _0324_ _0326_ i_decode_stage.reg_meta_o\[16\] VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__o21a_1
XFILLER_71_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_241 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4969_ clknet_leaf_1_clk_i _0149_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_138_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_164_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_300 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4823_ clknet_leaf_23_clk_i _0003_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_166_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4754_ _2299_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3705_ _1198_ _0806_ _0807_ _1199_ _1591_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__a221o_1
XFILLER_146_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4685_ net227 i_decode_stage.fetch_state_i\[37\] _1967_ VGND VGND VPWR VPWR _2265_
+ sky130_fd_sc_hd__mux2_1
XFILLER_162_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3636_ _0964_ _0972_ _0965_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__o21ba_1
XFILLER_162_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3567_ _0417_ _0608_ _1460_ _1199_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_142_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2518_ _0343_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__inv_6
XFILLER_115_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5306_ clknet_leaf_21_clk_i _0305_ net286 VGND VGND VPWR VPWR i_decode_stage.valid_i
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3498_ _1198_ _0927_ _1149_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__a21o_1
X_5237_ clknet_leaf_21_clk_i _0236_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[35\]
+ sky130_fd_sc_hd__dfrtp_1
X_2449_ _0396_ _0397_ _0398_ net253 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nor4_2
XFILLER_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5168_ clknet_leaf_28_clk_i net383 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[75\]
+ sky130_fd_sc_hd__dfrtp_1
X_5099_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[2\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[2\] sky130_fd_sc_hd__dfrtp_1
X_4119_ net60 _1928_ _1934_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__nor3_1
XFILLER_17_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_371 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 i_exec_stage.exec_state_o\[21\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_66_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4470_ i_decode_stage.reg_meta_o\[7\] net110 _2012_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__mux2_1
XFILLER_7_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3421_ _0415_ _0911_ _1320_ _0424_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__o211a_1
XFILLER_99_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3352_ _0540_ _0525_ _0545_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o21ai_1
XFILLER_98_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3283_ _0590_ _1179_ _1187_ _1184_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__o31ai_2
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5022_ clknet_leaf_23_clk_i i_decode_stage.decode_state_o\[137\] net289 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_347 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4806_ _2325_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
X_2998_ _0384_ _0908_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__o21ba_1
XFILLER_147_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4737_ net224 i_decode_stage.fetch_state_i\[63\] _1927_ VGND VGND VPWR VPWR _2291_
+ sky130_fd_sc_hd__mux2_1
XFILLER_147_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_18 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4668_ i_decode_stage.fetch_state_i\[25\] _1929_ _2127_ VGND VGND VPWR VPWR _0226_
+ sky130_fd_sc_hd__a21o_1
XFILLER_174_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3619_ _0972_ _1508_ _0966_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__o21ai_1
XFILLER_162_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4599_ _2227_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XFILLER_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_314 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3970_ net12 _1809_ _1818_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[1\] sky130_fd_sc_hd__a21o_1
XFILLER_90_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2921_ _0324_ _0326_ i_decode_stage.reg_meta_o\[19\] VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__o21ai_2
XFILLER_31_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2852_ i_decode_stage.reg_meta_o\[31\] _0727_ _0386_ _0766_ VGND VGND VPWR VPWR _0767_
+ sky130_fd_sc_hd__a211o_1
X_2783_ i_decode_stage.decode_state_o\[126\] _0631_ i_decode_stage.decode_state_o\[138\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a221o_1
XFILLER_31_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4522_ _2188_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
XFILLER_144_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4453_ _2042_ _2152_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__nor2_1
XFILLER_8_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3404_ _0666_ _0875_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nor2_1
XFILLER_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4384_ _2095_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__nor2_1
X_3335_ _0662_ _0625_ _1237_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__o21ai_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3266_ _1169_ _1170_ _0660_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__mux2_1
XFILLER_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5005_ clknet_leaf_0_clk_i _0185_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[66\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3197_ i_exec_stage.alu_out\[0\] _1106_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__nand2_1
XFILLER_94_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3120_ _0384_ _1030_ _0752_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__o211a_1
XFILLER_68_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3051_ _2333_ _0961_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21o_1
XFILLER_83_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3953_ _1110_ _1020_ _0855_ _1112_ _1784_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__o221ai_2
X_3884_ _0422_ _1732_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__nor2_1
X_2904_ _0484_ _0796_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2b_1
XFILLER_31_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2835_ i_decode_stage.decode_state_o\[67\] _0731_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__nand2_1
XFILLER_136_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2766_ _0673_ _0684_ _0422_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__mux2_1
XFILLER_160_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2697_ _0465_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__and2_1
XFILLER_105_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4505_ i_decode_stage.reg_meta_o\[24\] net108 _2179_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__mux2_1
XFILLER_145_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4436_ net219 _1928_ _2135_ _2138_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__a22o_1
XFILLER_132_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4367_ net204 _1840_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__or2_1
X_3318_ _1059_ _1079_ _0523_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__mux2_1
XFILLER_98_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4298_ net37 _2031_ _2033_ _1928_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__a211o_1
XFILLER_86_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3249_ i_decode_stage.decode_state_o\[239\] _0429_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__and2_1
XFILLER_86_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_11 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_2_1__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_1__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
XTAP_2773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_1_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_1_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_72_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_158_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2620_ i_exec_stage.data_fwd_o\[29\] _0553_ _0460_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__mux2_2
XFILLER_70_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2551_ i_decode_stage.decode_state_o\[123\] _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nand2_1
XFILLER_127_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2482_ _0428_ _0405_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__o21ai_1
Xoutput139 net139 VGND VGND VPWR VPWR dmem_addr_o[17] sky130_fd_sc_hd__clkbuf_4
X_5270_ clknet_leaf_24_clk_i _0269_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_114_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4221_ _1989_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XFILLER_68_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4152_ i_decode_stage.fetch_state_i\[12\] i_decode_stage.decode_state_o\[20\] _1936_
+ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__mux2_1
X_3103_ _0556_ _0743_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__and2_1
X_4083_ _1897_ _1898_ _1899_ _1900_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__or4_1
XFILLER_68_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3034_ _0945_ _0919_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__nand2_1
XFILLER_95_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4985_ clknet_leaf_30_clk_i _0165_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[46\]
+ sky130_fd_sc_hd__dfrtp_1
X_3936_ _1795_ net195 _1110_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__mux2_1
XFILLER_23_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3867_ _1025_ _0746_ _1017_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__nand3_1
X_3798_ _1642_ _1679_ _0394_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__mux2_1
X_2818_ _0732_ _0339_ _0384_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__o21ai_4
XFILLER_145_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2749_ i_exec_stage.data_fwd_o\[9\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0670_
+ sky130_fd_sc_hd__or4_1
XFILLER_11_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4419_ net216 _1928_ _2121_ _2124_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a22o_1
XFILLER_143_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_228 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput19 dmem_rdata_i[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_155_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_285 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4770_ _2307_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
XFILLER_14_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3721_ _1286_ _1501_ _1606_ _1278_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__o22a_1
XFILLER_119_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_347 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3652_ _1373_ _1541_ _0590_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
X_2603_ _0527_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__buf_6
X_3583_ _1298_ _1475_ _0590_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__mux2_1
XFILLER_127_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2534_ i_mem_slice_stage.mem_state_o\[61\] i_mem_slice_stage.mem_state_o\[22\] _0453_
+ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__mux2_2
XFILLER_142_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2465_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_4
XFILLER_69_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5253_ clknet_leaf_20_clk_i _0252_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[51\]
+ sky130_fd_sc_hd__dfrtp_1
X_2396_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[119\] VGND VGND
+ VPWR VPWR _0349_ sky130_fd_sc_hd__or2b_1
X_5184_ clknet_leaf_19_clk_i net357 net288 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[91\]
+ sky130_fd_sc_hd__dfrtp_1
X_4204_ _1980_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_84_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4135_ _1945_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
X_4066_ _1866_ _1867_ _1879_ _1882_ _1883_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__o32a_1
XFILLER_71_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3017_ _2336_ _2341_ net243 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__and3_1
XFILLER_24_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4968_ clknet_leaf_2_clk_i _0148_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[29\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3919_ net196 _1106_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__nand2_1
X_4899_ clknet_leaf_15_clk_i _0079_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[233\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_137_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_358 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_312 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4822_ clknet_leaf_23_clk_i _0002_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_61_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4753_ i_exec_stage.data_fwd_o\[7\] net158 _1839_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__mux2_1
XFILLER_119_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3704_ _0417_ _0478_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__nor2_1
XFILLER_146_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4684_ _2264_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3635_ _0966_ _0975_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__nand2_1
XFILLER_161_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3566_ _0608_ _0857_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__nand2_1
XFILLER_1_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3497_ _1088_ _1171_ _1183_ _1287_ _1393_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__o221a_1
XFILLER_115_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2517_ _0451_ _0461_ _0462_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a2bb2o_4
X_5305_ clknet_leaf_23_clk_i _0304_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[39\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_170_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2448_ i_decode_stage.reg_meta_o\[81\] net274 _0371_ _0372_ VGND VGND VPWR VPWR _0398_
+ sky130_fd_sc_hd__nand4_1
X_5236_ clknet_leaf_22_clk_i _0235_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[34\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_102_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2379_ _0307_ _0308_ _0309_ _0310_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__and4_1
XFILLER_69_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5167_ clknet_leaf_29_clk_i net394 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[74\]
+ sky130_fd_sc_hd__dfrtp_1
X_5098_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[1\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_110_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4118_ net62 net61 _1930_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__or3b_1
XFILLER_84_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4049_ _0665_ _0873_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__nor2_1
XFILLER_71_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold8 i_exec_stage.reg_meta_o\[3\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_47_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_156_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3420_ _1198_ _0911_ _0672_ _0417_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_109_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3351_ _0594_ _1252_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__and3_1
XFILLER_124_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_394 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3282_ _0525_ _0545_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__and2_1
XFILLER_112_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5021_ clknet_leaf_26_clk_i i_decode_stage.decode_state_o\[147\] net283 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_66_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4805_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[147\] _1838_
+ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__mux2_1
XFILLER_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2997_ i_decode_stage.decode_state_o\[48\] _0339_ _0751_ i_decode_stage.decode_state_o\[132\]
+ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__a22o_1
X_4736_ _2290_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4667_ i_decode_stage.fetch_state_i\[24\] _1929_ _2123_ VGND VGND VPWR VPWR _0225_
+ sky130_fd_sc_hd__a21o_1
XFILLER_162_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3618_ _0966_ _0972_ _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__or3_1
XFILLER_162_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4598_ i_decode_stage.reg_meta_o\[70\] net85 _2207_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__mux2_1
XFILLER_1_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3549_ _0411_ _1428_ _1431_ _1443_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__a211o_4
X_5219_ clknet_leaf_21_clk_i _0218_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_151_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_326 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_392 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_106 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_74 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2920_ _0324_ _0326_ net246 VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__or3b_2
XFILLER_50_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2851_ _2336_ _2341_ net259 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and3_1
X_2782_ _0358_ _0698_ _0699_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__o31a_2
XFILLER_156_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_144_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4521_ i_decode_stage.reg_meta_o\[32\] net117 _2179_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__mux2_1
XFILLER_144_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4452_ _0722_ _2150_ _2151_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__and3_1
XFILLER_7_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3403_ _1299_ _1301_ _1303_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__or3_1
XFILLER_104_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4383_ net208 _2091_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__nor2_1
X_3334_ _0660_ _0514_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__or2_1
XFILLER_124_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3265_ _0610_ _0642_ _0422_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__mux2_1
XFILLER_105_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5004_ clknet_leaf_1_clk_i _0184_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[65\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3196_ i_decode_stage.decode_state_o\[0\] _0601_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__nor2_2
XFILLER_66_451 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4719_ net214 i_decode_stage.fetch_state_i\[54\] _1927_ VGND VGND VPWR VPWR _2282_
+ sky130_fd_sc_hd__mux2_1
XFILLER_108_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_173_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3050_ i_decode_stage.decode_state_o\[57\] _0731_ _0733_ VGND VGND VPWR VPWR _0962_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_68_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3952_ _0601_ _1804_ _1782_ _1800_ _1783_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__a221o_1
XFILLER_90_295 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3883_ _1035_ _1026_ _1027_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__nand3_1
X_2903_ _0789_ _0790_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__or2b_1
XFILLER_149_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2834_ i_exec_stage.data_fwd_o\[28\] _0726_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__o21ai_4
XFILLER_31_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2765_ _0677_ _0683_ _0345_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__mux2_1
XFILLER_117_423 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4504_ _0722_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__buf_12
XFILLER_160_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2696_ _0451_ _0620_ _0621_ _0492_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_105_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4435_ _2042_ _2137_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__or2_1
XFILLER_160_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4366_ _2081_ _2082_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__nor2_1
X_3317_ _0662_ _1095_ _0590_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__o21ai_1
XFILLER_113_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4297_ _2032_ _2019_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__nor2_2
XFILLER_86_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3248_ _0662_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__or2_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ _0678_ _0682_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__and2_1
XFILLER_39_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_23 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_158_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2550_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__nand2_2
XFILLER_142_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2481_ _0428_ _0405_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4220_ i_decode_stage.decode_state_o\[53\] i_decode_stage.fetch_state_i\[45\] _1982_
+ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__mux2_1
XFILLER_96_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4151_ _1953_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_3102_ _0556_ _0743_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__nor2_2
X_4082_ _0535_ _1020_ _0730_ _0530_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__o22ai_1
XFILLER_83_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3033_ _0346_ i_decode_stage.decode_state_o\[133\] _0347_ _0649_ VGND VGND VPWR VPWR
+ _0945_ sky130_fd_sc_hd__a22o_1
XFILLER_55_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4984_ clknet_leaf_30_clk_i _0164_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[45\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_168_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3935_ _0794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__inv_1
XFILLER_20_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3866_ _1025_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__xor2_1
XFILLER_31_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3797_ _0344_ _0568_ _1069_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__a21oi_1
X_2817_ i_decode_stage.decode_state_o\[100\] VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__inv_2
XFILLER_11_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2748_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[52\] VGND VGND VPWR VPWR _0669_
+ sky130_fd_sc_hd__o31a_1
XFILLER_145_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2679_ i_decode_stage.decode_state_o\[118\] _0493_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nand2_1
X_4418_ _2042_ _2123_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__or2_1
XFILLER_160_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4349_ net231 _1840_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__or2_1
XFILLER_143_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3720_ _1412_ _1458_ _1605_ _1281_ _0448_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__a221o_1
XTAP_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_159_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3651_ _1537_ _1540_ _0523_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__mux2_1
XFILLER_119_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3582_ _1390_ _1474_ _0660_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__mux2_1
X_2602_ _0527_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__or2_1
XFILLER_173_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2533_ _0451_ _0475_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__o21ai_4
XFILLER_170_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2464_ i_decode_stage.decode_state_o\[237\] _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__or2_1
X_5252_ clknet_leaf_22_clk_i _0251_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[50\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2395_ i_exec_stage.data_fwd_o\[36\] VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__inv_2
X_4203_ i_decode_stage.decode_state_o\[45\] i_decode_stage.fetch_state_i\[37\] _1840_
+ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__mux2_1
X_5183_ clknet_leaf_20_clk_i net391 net286 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[90\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4134_ i_decode_stage.fetch_state_i\[3\] i_decode_stage.decode_state_o\[11\] _1936_
+ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__mux2_1
XFILLER_84_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4065_ _0615_ _1785_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__nor2_1
XFILLER_83_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3016_ _0633_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__xnor2_1
XFILLER_36_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4967_ clknet_leaf_1_clk_i _0147_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4898_ clknet_leaf_15_clk_i _0078_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[232\]
+ sky130_fd_sc_hd__dfrtp_4
X_3918_ _0846_ _0847_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__and2_2
X_3849_ _0738_ _1727_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__or2_1
XFILLER_164_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_0_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_0_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_121_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4821_ clknet_leaf_15_clk_i _0001_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_61_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4752_ _2298_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XFILLER_21_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3703_ _0448_ _1254_ _1589_ _1501_ _1242_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__o32a_1
XFILLER_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4683_ net226 i_decode_stage.fetch_state_i\[36\] _1967_ VGND VGND VPWR VPWR _2264_
+ sky130_fd_sc_hd__mux2_1
X_3634_ _0411_ _1509_ _1510_ _1524_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__a31o_4
XFILLER_146_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_161_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3565_ _1285_ _1458_ _0590_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__mux2_2
XFILLER_127_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3496_ _1194_ _1326_ _1392_ _1041_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__o22a_1
X_2516_ _0346_ i_decode_stage.decode_state_o\[127\] VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__or2b_1
X_5304_ clknet_leaf_23_clk_i _0303_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[38\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5235_ clknet_leaf_23_clk_i _0234_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_2447_ _0364_ _0365_ _0366_ _0367_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__nand4_1
XFILLER_130_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2378_ _0324_ _0326_ net242 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__or3_1
XFILLER_69_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5166_ clknet_leaf_28_clk_i net350 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[73\]
+ sky130_fd_sc_hd__dfrtp_1
X_5097_ clknet_leaf_8_clk_i i_mem_slice_stage.pre_data\[0\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[0\] sky130_fd_sc_hd__dfrtp_1
X_4117_ i_decode_stage.decode_state_o\[3\] _1929_ _1933_ VGND VGND VPWR VPWR _0001_
+ sky130_fd_sc_hd__a21o_1
X_4048_ _1861_ _1863_ _1864_ _1865_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__o31a_1
XFILLER_84_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold9 i_exec_stage.exec_state_o\[33\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3350_ _0662_ _0587_ _0707_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__o21ai_1
XFILLER_152_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3281_ _1129_ _1185_ _0594_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__o21ai_1
XFILLER_112_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5020_ clknet_leaf_15_clk_i _0200_ net290 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[81\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4804_ _2324_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
XFILLER_22_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4735_ net223 i_decode_stage.fetch_state_i\[62\] _1927_ VGND VGND VPWR VPWR _2290_
+ sky130_fd_sc_hd__mux2_1
X_2996_ _0386_ _0905_ _0906_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__o31ai_4
XFILLER_9_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_159_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4666_ _2259_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
X_3617_ _1488_ _1491_ _0975_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__o21a_1
X_4597_ _2226_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3548_ _1129_ _1436_ _1439_ _0842_ _1442_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a221o_1
XFILLER_143_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3479_ _0946_ _1347_ _0935_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__a21oi_1
X_5218_ clknet_leaf_26_clk_i _0217_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[16\]
+ sky130_fd_sc_hd__dfrtp_1
X_5149_ clknet_leaf_6_clk_i net375 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[56\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_118 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_86 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2850_ _0756_ _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__or2_1
XFILLER_43_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2781_ i_exec_stage.data_fwd_o\[3\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0700_
+ sky130_fd_sc_hd__or4_1
XFILLER_157_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4520_ _2187_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
XFILLER_172_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4451_ net223 _2145_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__nand2_1
XFILLER_7_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3402_ _0660_ _1173_ _1302_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__a21oi_1
XFILLER_116_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4382_ net208 _2091_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__and2_1
X_3333_ _0898_ _1212_ _1233_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__o31a_1
XFILLER_124_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3264_ _0624_ _0513_ _0527_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__mux2_1
XFILLER_112_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5003_ clknet_leaf_0_clk_i _0183_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[64\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3195_ i_exec_stage.alu_out\[1\] i_exec_stage.alu_out\[0\] _1105_ VGND VGND VPWR
+ VPWR net162 sky130_fd_sc_hd__nor3_1
XFILLER_66_463 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2979_ _0525_ _0703_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__nor2_1
X_4718_ _2281_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4649_ i_decode_stage.fetch_state_i\[14\] _2087_ _2234_ VGND VGND VPWR VPWR _2252_
+ sky130_fd_sc_hd__mux2_1
XFILLER_163_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_148 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_162 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3951_ _0730_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__inv_2
XFILLER_91_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_105 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2902_ _0815_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nand2b_2
XFILLER_90_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3882_ _1035_ _1758_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__xnor2_1
X_2833_ i_decode_stage.reg_meta_o\[33\] _0727_ _0386_ _0747_ VGND VGND VPWR VPWR _0748_
+ sky130_fd_sc_hd__a211o_1
XFILLER_31_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2764_ _0347_ _0678_ _0682_ i_decode_stage.decode_state_o\[129\] _0346_ VGND VGND
+ VPWR VPWR _0683_ sky130_fd_sc_hd__a32oi_4
XFILLER_144_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4503_ _2178_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
XFILLER_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2695_ i_decode_stage.decode_state_o\[120\] _0493_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__nand2_1
XFILLER_160_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_287 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4434_ net219 _2131_ _2136_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__o21a_1
XFILLER_160_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4365_ net203 _2075_ net204 VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__a21oi_1
X_3316_ _0660_ _1084_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__nor2_1
XFILLER_113_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4296_ net61 VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__inv_2
XFILLER_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3247_ _1042_ _1152_ _0394_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__mux2_1
XFILLER_100_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3178_ _0344_ _0677_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a21o_1
XTAP_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_173_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_173_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2480_ i_decode_stage.decode_state_o\[239\] _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__nand2_8
XFILLER_114_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4150_ i_decode_stage.fetch_state_i\[11\] i_decode_stage.decode_state_o\[19\] _1936_
+ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__mux2_1
X_3101_ _0736_ _0737_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nor2_1
XFILLER_95_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4081_ _0561_ _0768_ _0776_ _0468_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__a22o_1
XFILLER_68_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3032_ _0672_ _0910_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__and2b_1
XFILLER_83_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4983_ clknet_leaf_30_clk_i _0163_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[44\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3934_ _1794_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_1
XFILLER_23_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3865_ _1013_ _1016_ _1710_ _1742_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__a31o_1
X_2816_ _0339_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__buf_6
X_3796_ _1421_ _1374_ _1129_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__a21oi_1
XFILLER_145_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2747_ _0363_ _0369_ _0374_ net272 VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__and4_1
XFILLER_11_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2678_ i_exec_stage.data_fwd_o\[15\] _0605_ _0460_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__mux2_2
XFILLER_160_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4417_ net216 _2117_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__o21a_1
XFILLER_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4348_ net231 _2065_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__xor2_1
X_4279_ net59 net62 net60 _1937_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__or4bb_2
XFILLER_47_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_163_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3650_ _0421_ _1538_ _1539_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__a21o_1
XFILLER_174_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3581_ _1473_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__inv_2
X_2601_ _0532_ _0537_ _0465_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__mux2_1
XFILLER_127_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2532_ _0476_ _0346_ _0462_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__o21ai_1
XFILLER_142_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5251_ clknet_leaf_21_clk_i _0250_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[49\]
+ sky130_fd_sc_hd__dfrtp_1
X_2463_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__buf_8
XFILLER_102_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4202_ _1979_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_2394_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nor2_8
XFILLER_68_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5182_ clknet_leaf_28_clk_i net413 net131 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[89\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_29_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4133_ _1944_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_95_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4064_ _1877_ _1881_ _1872_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__a21oi_1
XFILLER_84_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3015_ _2333_ _0925_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a21oi_4
XFILLER_36_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4966_ clknet_leaf_1_clk_i _0146_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[27\]
+ sky130_fd_sc_hd__dfrtp_1
X_4897_ clknet_leaf_12_clk_i _0077_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[100\]
+ sky130_fd_sc_hd__dfrtp_4
X_3917_ _0855_ _1106_ _1784_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__o21ai_1
XFILLER_22_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3848_ _1016_ _1710_ _1014_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__a21oi_1
XFILLER_153_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3779_ _1624_ _1661_ _0422_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
XFILLER_106_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_156_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4820_ clknet_leaf_22_clk_i _0000_ VGND VGND VPWR VPWR i_decode_stage.valid_o sky130_fd_sc_hd__dfxtp_2
XTAP_2391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_266 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4751_ i_exec_stage.data_fwd_o\[6\] net157 _1839_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__mux2_1
XFILLER_159_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3702_ _1326_ _1434_ _1588_ _1041_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__o22ai_1
XFILLER_119_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4682_ _2263_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
XFILLER_174_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3633_ _0430_ _1512_ _1523_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__o21ai_1
XFILLER_174_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3564_ _1371_ _1457_ _0523_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__mux2_1
X_3495_ _0660_ _1297_ _1391_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__o21ai_1
X_2515_ _0346_ i_decode_stage.decode_state_o\[100\] _0347_ VGND VGND VPWR VPWR _0462_
+ sky130_fd_sc_hd__a21oi_4
X_5303_ clknet_leaf_24_clk_i _0302_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[37\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_130_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5234_ clknet_leaf_22_clk_i _0233_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_2446_ _0359_ _0360_ _0361_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nand3_1
XFILLER_130_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5165_ clknet_leaf_23_clk_i net388 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[72\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_69_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4116_ net62 net60 _0722_ _1932_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__and4bb_1
X_2377_ i_mem_slice_stage.mem_state_o\[71\] _0328_ _0329_ _0330_ VGND VGND VPWR VPWR
+ net242 sky130_fd_sc_hd__a22o_2
XFILLER_69_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5096_ clknet_leaf_23_clk_i i_exec_stage.valid net289 VGND VGND VPWR VPWR i_exec_stage.valid_o
+ sky130_fd_sc_hd__dfrtp_1
X_4047_ _0665_ _0873_ net195 _1862_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_17_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4949_ clknet_leaf_1_clk_i _0129_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_138_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_214 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_171_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3280_ _0590_ _1180_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__o21a_1
XFILLER_112_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_38_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4803_ i_exec_stage.data_fwd_o\[32\] net154 _1838_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__mux2_1
XFILLER_21_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4734_ _2289_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
X_2995_ i_exec_stage.data_fwd_o\[9\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0907_
+ sky130_fd_sc_hd__or4_1
XFILLER_159_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4665_ i_decode_stage.fetch_state_i\[23\] _2118_ _2234_ VGND VGND VPWR VPWR _2259_
+ sky130_fd_sc_hd__mux2_1
X_3616_ _0411_ _1493_ _1495_ _1507_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__a211o_4
X_4596_ i_decode_stage.reg_meta_o\[69\] net84 _2207_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__mux2_1
XFILLER_162_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3547_ _1129_ _1441_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__nor2_1
XFILLER_103_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3478_ _1369_ _1375_ _1129_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__mux2_1
XFILLER_130_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2429_ _0358_ _0375_ _0379_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__o31a_2
X_5217_ clknet_leaf_21_clk_i _0216_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_151_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5148_ clknet_leaf_6_clk_i net343 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[55\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_96_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5079_ clknet_leaf_27_clk_i i_decode_stage.decode_state_o\[23\] net283 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[54\] sky130_fd_sc_hd__dfrtp_1
XFILLER_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_80_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_400 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2780_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[46\] VGND VGND VPWR VPWR _0699_
+ sky130_fd_sc_hd__o31a_1
XFILLER_172_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4450_ net223 _2145_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__or2_1
XFILLER_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3401_ _0662_ _1170_ _1088_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__a21o_1
X_4381_ net138 _2047_ _2048_ _2093_ _2094_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__o221a_1
X_3332_ _0430_ _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__nor2_1
XFILLER_98_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3263_ _1164_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__xnor2_1
XFILLER_105_19 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3194_ i_decode_stage.decode_state_o\[0\] _0601_ net199 VGND VGND VPWR VPWR _1105_
+ sky130_fd_sc_hd__a21bo_1
X_5002_ clknet_leaf_30_clk_i _0182_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2978_ _0525_ _0703_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__and2_1
XFILLER_22_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4717_ net213 i_decode_stage.fetch_state_i\[53\] _1927_ VGND VGND VPWR VPWR _2281_
+ sky130_fd_sc_hd__mux2_1
XFILLER_147_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4648_ _2251_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_162_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_162_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4579_ _2217_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_174 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_342 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_423 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3950_ _0601_ _1803_ _1780_ _1800_ _1781_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__a221o_1
XFILLER_90_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2901_ _0500_ _0814_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__nand2_1
XFILLER_44_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3881_ _1025_ _1743_ _1023_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__a21oi_1
X_2832_ _2336_ _2341_ net261 VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__and3_1
XFILLER_157_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2763_ _0358_ _0680_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or3_2
XFILLER_129_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4502_ i_decode_stage.reg_meta_o\[23\] net107 _2012_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__mux2_1
XFILLER_172_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2694_ i_exec_stage.data_fwd_o\[17\] _0619_ _0460_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__mux2_1
XFILLER_160_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4433_ net219 _2131_ _1926_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4364_ net203 net204 _2075_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__and3_1
X_3315_ _0707_ _1218_ _1217_ _1187_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__o22a_1
XFILLER_113_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4295_ net62 net60 _1930_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__and3b_1
XFILLER_112_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3246_ _0404_ _0893_ _0343_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__mux2_1
XFILLER_113_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3177_ _0465_ _0666_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__and2_1
XFILLER_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_168_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3100_ _0551_ _1005_ _0765_ _1008_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__o221a_1
XFILLER_95_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4080_ _0549_ _0749_ _0759_ _0566_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__a22o_1
X_3031_ _0858_ _0941_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a21o_1
XFILLER_83_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4982_ clknet_leaf_15_clk_i _0162_ net289 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[43\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3933_ _1793_ net194 _1110_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__mux2_1
XFILLER_149_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3864_ _0736_ _1014_ _0737_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__o21ba_1
XFILLER_20_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2815_ i_exec_stage.data_fwd_o\[30\] _0726_ _0729_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__o21ai_4
XFILLER_31_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3795_ _0430_ _1675_ _1676_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__or3_1
XFILLER_157_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2746_ i_mem_slice_stage.mem_state_o\[79\] _0328_ _0667_ _0330_ VGND VGND VPWR VPWR
+ net272 sky130_fd_sc_hd__a22o_1
XFILLER_160_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_255 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2677_ net247 i_decode_stage.reg_meta_o\[58\] _0457_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__mux2_1
XFILLER_160_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4416_ net216 _2117_ _1926_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__a21oi_1
XFILLER_132_258 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4347_ net160 _2047_ _2048_ _2067_ _2068_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__o221a_1
X_4278_ _2018_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
XFILLER_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3229_ _0540_ _1083_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__nor2_1
XTAP_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_220 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_247 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_158_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3580_ _1432_ _1472_ _0421_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__mux2_1
XFILLER_139_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2600_ _0451_ _0535_ _0462_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_173_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2531_ i_decode_stage.decode_state_o\[125\] VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__inv_2
XFILLER_142_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5250_ clknet_leaf_21_clk_i _0249_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[48\]
+ sky130_fd_sc_hd__dfrtp_1
X_2462_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[239\]
+ i_decode_stage.decode_state_o\[238\] VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__or3b_1
XFILLER_5_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4201_ i_decode_stage.decode_state_o\[44\] i_decode_stage.fetch_state_i\[36\] _1840_
+ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__mux2_1
XFILLER_142_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2393_ i_decode_stage.decode_state_o\[235\] VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__buf_12
X_5181_ clknet_leaf_29_clk_i net410 net131 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[88\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_96_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_131 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4132_ i_decode_stage.fetch_state_i\[2\] i_decode_stage.decode_state_o\[10\] _1936_
+ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__mux2_1
XFILLER_110_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4063_ _1870_ _1875_ _1874_ _1880_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__a211o_1
XFILLER_28_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3014_ i_decode_stage.decode_state_o\[51\] _0731_ _0733_ VGND VGND VPWR VPWR _0926_
+ sky130_fd_sc_hd__a21oi_2
XFILLER_37_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4965_ clknet_leaf_3_clk_i _0145_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[26\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3916_ net195 _1106_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__nand2_1
X_4896_ clknet_leaf_14_clk_i _0076_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[134\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3847_ _0411_ _1711_ _1712_ _1726_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__a31o_4
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3778_ _0345_ _0563_ _0471_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__a21o_1
XFILLER_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2729_ _0363_ _0369_ _0374_ net243 VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__and4_1
XFILLER_161_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_154_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_101_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_79 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_164_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4750_ _2297_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XTAP_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3701_ _1518_ _1587_ _0660_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
XFILLER_147_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4681_ net225 i_decode_stage.fetch_state_i\[35\] _1967_ VGND VGND VPWR VPWR _2263_
+ sky130_fd_sc_hd__mux2_1
XFILLER_174_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3632_ _0591_ _1477_ _1513_ _1516_ _1522_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__o2111a_1
XFILLER_174_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3563_ _1413_ _1456_ _0394_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__mux2_1
X_5302_ clknet_leaf_23_clk_i _0301_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[36\]
+ sky130_fd_sc_hd__dfxtp_1
X_3494_ _0525_ _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__or2_1
X_2514_ i_exec_stage.data_fwd_o\[24\] _0458_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__mux2_2
XFILLER_103_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5233_ clknet_leaf_19_clk_i _0232_ net288 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[31\]
+ sky130_fd_sc_hd__dfrtp_1
X_2445_ _0363_ _0369_ _0374_ i_decode_stage.reg_meta_o\[45\] VGND VGND VPWR VPWR _0395_
+ sky130_fd_sc_hd__a31oi_2
XFILLER_124_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5164_ clknet_leaf_15_clk_i net352 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[71\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_96_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4115_ _1931_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__inv_2
X_2376_ i_mem_slice_stage.mem_state_o\[37\] VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__inv_4
XFILLER_69_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5095_ clknet_leaf_22_clk_i i_decode_stage.decode_state_o\[39\] net286 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[70\] sky130_fd_sc_hd__dfrtp_1
XFILLER_29_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4046_ _1091_ _0864_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__nor2_1
XFILLER_84_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_169_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4948_ clknet_leaf_0_clk_i _0128_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4879_ clknet_leaf_15_clk_i _0059_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_138_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_152_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_165_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput270 net270 VGND VGND VPWR VPWR rf_wr_data_o[6] sky130_fd_sc_hd__buf_2
XFILLER_121_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_226 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_156_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_331 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4802_ _2323_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
X_2994_ _0324_ _0326_ i_decode_stage.reg_meta_o\[14\] VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__o21a_1
XFILLER_61_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4733_ net221 i_decode_stage.fetch_state_i\[61\] _1927_ VGND VGND VPWR VPWR _2289_
+ sky130_fd_sc_hd__mux2_1
XFILLER_30_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4664_ i_decode_stage.fetch_state_i\[22\] _1929_ _2114_ VGND VGND VPWR VPWR _0223_
+ sky130_fd_sc_hd__a21o_1
XFILLER_135_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3615_ _1500_ _1506_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__or2_1
X_4595_ _2225_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_3546_ _0662_ _0587_ _1348_ _1440_ _0584_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__o32a_1
XFILLER_143_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_28 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3477_ _1287_ _1125_ _1137_ _1088_ _1374_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__o221ai_2
XFILLER_103_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5216_ clknet_leaf_21_clk_i _0215_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_2428_ i_exec_stage.data_fwd_o\[1\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0380_
+ sky130_fd_sc_hd__or4_1
X_5147_ clknet_leaf_6_clk_i net372 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[54\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_84_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2359_ i_exec_stage.data_fwd_o\[37\] i_decode_stage.decode_state_o\[128\] VGND VGND
+ VPWR VPWR _0313_ sky130_fd_sc_hd__or2b_1
XFILLER_69_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_101 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5078_ clknet_leaf_29_clk_i i_decode_stage.decode_state_o\[22\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[53\] sky130_fd_sc_hd__dfrtp_1
X_4029_ _1843_ _1844_ _1845_ _1846_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__or4b_1
XFILLER_53_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_40 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_102_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_412 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3400_ _1287_ _1300_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__nor2_1
XFILLER_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4380_ net207 _1840_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__or2_1
X_3331_ _1212_ _1233_ _0898_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__o21a_1
XFILLER_125_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_161 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_312 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3262_ _1148_ _1145_ _0891_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__a21o_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3193_ _1104_ VGND VGND VPWR VPWR i_exec_stage.alu_out\[0\] sky130_fd_sc_hd__buf_4
XFILLER_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5001_ clknet_leaf_0_clk_i _0181_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2977_ _0428_ _0405_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a21oi_2
X_4716_ _2280_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4647_ i_decode_stage.fetch_state_i\[13\] _2083_ _2234_ VGND VGND VPWR VPWR _2251_
+ sky130_fd_sc_hd__mux2_1
XFILLER_162_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_162_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4578_ i_decode_stage.reg_meta_o\[60\] net74 _2207_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__mux2_1
XFILLER_1_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3529_ _1129_ _1417_ _1420_ _0833_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__a221o_1
XFILLER_115_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_162_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2900_ _0500_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__nor2_1
XFILLER_32_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3880_ _0411_ _1744_ _1757_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__a21o_4
XFILLER_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2831_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__inv_2
X_2762_ _0396_ _0397_ _0398_ i_decode_stage.reg_meta_o\[49\] VGND VGND VPWR VPWR _0681_
+ sky130_fd_sc_hd__o31a_1
XFILLER_157_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4501_ _2177_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
XFILLER_144_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4432_ _1691_ _1703_ _1705_ _1924_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__or4_1
X_2693_ net249 i_decode_stage.reg_meta_o\[60\] _0457_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__mux2_1
XFILLER_172_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4363_ net134 _2047_ _2048_ _2079_ _2080_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__o221a_1
X_3314_ _1054_ _1071_ _0525_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__mux2_1
XFILLER_113_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4294_ _2028_ _2030_ _0346_ _1840_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__o2bb2a_1
X_3245_ _0419_ _1148_ _0891_ _0424_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__o221a_1
XFILLER_100_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_132_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3176_ _1074_ _0589_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__nand2_4
XFILLER_67_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_54_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_52 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_96 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_2711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_173 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3030_ _0608_ _0857_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__and2b_1
XFILLER_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4981_ clknet_leaf_24_clk_i _0161_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[128\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_17_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3932_ _0803_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__inv_2
XFILLER_51_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3863_ _1728_ _1729_ _1741_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__a21o_4
XFILLER_20_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2814_ i_decode_stage.reg_meta_o\[35\] _0727_ _0386_ _0728_ VGND VGND VPWR VPWR _0729_
+ sky130_fd_sc_hd__a211o_1
XFILLER_164_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3794_ _1674_ _1656_ _0764_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__a21oi_1
XFILLER_173_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2745_ i_mem_slice_stage.mem_state_o\[47\] i_mem_slice_stage.mem_state_o\[8\] _0453_
+ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__mux2_1
XFILLER_133_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2676_ i_mem_slice_stage.mem_state_o\[85\] _0328_ _0604_ _0330_ VGND VGND VPWR VPWR
+ net247 sky130_fd_sc_hd__a22o_1
XFILLER_160_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4415_ net146 _1924_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__or2_1
XFILLER_160_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4346_ net230 _1840_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__or2_1
XFILLER_113_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4277_ i_decode_stage.decode_state_o\[100\] net58 _2012_ VGND VGND VPWR VPWR _2018_
+ sky130_fd_sc_hd__mux2_1
XFILLER_143_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3228_ _0540_ _1076_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__o21ai_1
X_3159_ _1068_ _1070_ _0421_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__mux2_1
XTAP_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_73_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_173_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_170_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2530_ i_exec_stage.data_fwd_o\[22\] _0474_ _0460_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__mux2_2
XFILLER_142_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2461_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_16
XFILLER_115_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4200_ _1978_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
X_2392_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__buf_8
X_5180_ clknet_leaf_29_clk_i net409 net131 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[87\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_122_292 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4131_ i_decode_stage.decode_state_o\[7\] _1929_ _1943_ VGND VGND VPWR VPWR _0005_
+ sky130_fd_sc_hd__a21o_1
XFILLER_96_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_143 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4062_ _1871_ _1873_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__and2b_1
XFILLER_83_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3013_ _0386_ _0922_ _0923_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__o31ai_4
XFILLER_37_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4964_ clknet_leaf_2_clk_i _0144_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[25\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3915_ _1782_ _1774_ _1783_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__a21o_1
X_4895_ clknet_leaf_12_clk_i _0075_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[133\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_149_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3846_ _1715_ _1722_ _1725_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__or3b_1
X_3777_ _0411_ _1658_ _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__and3_1
XFILLER_20_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2728_ i_mem_slice_stage.mem_state_o\[81\] _0328_ _0651_ _0330_ VGND VGND VPWR VPWR
+ net243 sky130_fd_sc_hd__a22o_1
XFILLER_173_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_161_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_160_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2659_ _0384_ net192 _0580_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__o21ai_4
XFILLER_160_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_218 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4329_ net156 _2047_ _2048_ _2053_ _2054_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__o221a_1
XFILLER_170_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_14 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_164_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_207 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3700_ _1552_ _1586_ _0422_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
XTAP_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4680_ i_decode_stage.fetch_state_i\[34\] _1929_ _2043_ VGND VGND VPWR VPWR _0235_
+ sky130_fd_sc_hd__a21bo_1
XFILLER_41_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3631_ _0448_ _0717_ _1521_ _0712_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__a211o_1
X_3562_ _0344_ _0608_ _1077_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__a21oi_1
XFILLER_155_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2513_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__buf_8
X_5301_ clknet_leaf_24_clk_i _0300_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[35\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_6_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3493_ _0540_ _1388_ _1389_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__o21ai_1
XFILLER_142_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2444_ _0384_ net178 _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__o21ai_4
XFILLER_102_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5232_ clknet_leaf_18_clk_i _0231_ net288 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[30\]
+ sky130_fd_sc_hd__dfrtp_1
X_5163_ clknet_leaf_10_clk_i net360 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[70\]
+ sky130_fd_sc_hd__dfrtp_1
X_2375_ i_mem_slice_stage.mem_state_o\[39\] i_mem_slice_stage.mem_state_o\[0\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__mux2_2
XFILLER_111_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_68_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4114_ net61 _1930_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__nand2_1
XFILLER_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5094_ clknet_leaf_19_clk_i i_decode_stage.decode_state_o\[38\] net288 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[69\] sky130_fd_sc_hd__dfrtp_1
X_4045_ _1862_ net195 VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__and2_1
XFILLER_84_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4947_ clknet_leaf_3_clk_i _0127_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4878_ clknet_leaf_17_clk_i _0058_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_119_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3829_ _0763_ _1671_ _1693_ _0762_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__a211o_1
XFILLER_165_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput260 net260 VGND VGND VPWR VPWR rf_wr_data_o[26] sky130_fd_sc_hd__buf_2
XFILLER_0_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput271 net271 VGND VGND VPWR VPWR rf_wr_data_o[7] sky130_fd_sc_hd__buf_2
XFILLER_160_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_169_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4801_ i_exec_stage.data_fwd_o\[31\] net153 _1838_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__mux2_1
X_2993_ _2336_ _2341_ net272 VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__and3_1
XFILLER_61_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4732_ _2288_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4663_ i_decode_stage.fetch_state_i\[21\] _1929_ _2110_ VGND VGND VPWR VPWR _0222_
+ sky130_fd_sc_hd__a21o_1
X_3614_ _1074_ _1073_ _1501_ _1504_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__a311o_1
XFILLER_119_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4594_ i_decode_stage.reg_meta_o\[68\] net83 _2207_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__mux2_1
XFILLER_143_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3545_ _0582_ _1256_ _1322_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__o21a_1
XFILLER_128_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3476_ _1154_ _1326_ _1373_ _1041_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__o22a_1
XFILLER_103_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2427_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[44\] VGND VGND VPWR VPWR _0379_
+ sky130_fd_sc_hd__o31a_1
X_5215_ clknet_leaf_27_clk_i _0214_ net281 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_5146_ clknet_leaf_6_clk_i net344 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[53\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2358_ i_decode_stage.decode_state_o\[128\] i_exec_stage.data_fwd_o\[37\] VGND VGND
+ VPWR VPWR _0312_ sky130_fd_sc_hd__or2b_1
XFILLER_69_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5077_ clknet_leaf_29_clk_i i_decode_stage.decode_state_o\[21\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[52\] sky130_fd_sc_hd__dfrtp_1
X_4028_ _0498_ _0812_ _0978_ _0490_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__o22a_1
XFILLER_84_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_87_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_77 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_424 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3330_ _0447_ _0883_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__nor2_1
XFILLER_125_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3261_ _0660_ _0703_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__a211o_1
XFILLER_98_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5000_ clknet_leaf_0_clk_i _0180_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[61\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3192_ _0409_ _1036_ _1039_ _1103_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__a31o_1
XFILLER_79_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2976_ _0527_ _0404_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__nor2_1
XFILLER_148_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4715_ net212 i_decode_stage.fetch_state_i\[52\] _1927_ VGND VGND VPWR VPWR _2280_
+ sky130_fd_sc_hd__mux2_1
XFILLER_135_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4646_ _2250_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
XFILLER_135_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4577_ _2216_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XFILLER_150_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3528_ _1129_ _1423_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__nor2_1
XFILLER_104_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3459_ _1240_ _1357_ _0523_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__mux2_1
XFILLER_77_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5129_ clknet_leaf_3_clk_i net407 net285 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[36\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_29_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_138_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold70 i_exec_stage.exec_state_o\[4\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__clkdlybuf4s50_1
XFILLER_29_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2830_ _0725_ _0735_ _0738_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a22o_1
XFILLER_157_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2761_ _0363_ _0369_ _0374_ net269 VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__and4_1
XFILLER_157_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4500_ i_decode_stage.reg_meta_o\[22\] net106 _2012_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__mux2_1
XFILLER_61_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2692_ i_mem_slice_stage.mem_state_o\[87\] _0452_ _0618_ _0455_ VGND VGND VPWR VPWR
+ net249 sky130_fd_sc_hd__a22o_1
XFILLER_172_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4431_ net218 _1928_ _2130_ _2134_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a22o_1
XFILLER_6_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4362_ net203 _1840_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__or2_1
X_3313_ _0662_ _1065_ _0707_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__o21ai_1
X_4293_ _1928_ _2021_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__nor2_1
XFILLER_59_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3244_ _1149_ _0703_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__nand2_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3175_ _0593_ _0589_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__nor2_2
XFILLER_82_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_67_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2959_ _0322_ _0870_ _0871_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__a31o_1
XFILLER_157_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4629_ i_decode_stage.fetch_state_i\[4\] _2053_ _2234_ VGND VGND VPWR VPWR _2242_
+ sky130_fd_sc_hd__mux2_1
XFILLER_173_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_216 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_64 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_2789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_147_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_163_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4980_ clknet_leaf_24_clk_i _0160_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[127\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_51_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3931_ _1792_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__inv_2
X_3862_ _1017_ _1730_ _1731_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__a31o_1
XFILLER_165_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2813_ _2336_ _2341_ net263 VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__and3_1
XFILLER_20_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3793_ _0764_ _1674_ _1656_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__and3_1
XFILLER_157_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2744_ _0346_ i_decode_stage.decode_state_o\[131\] _0347_ _0665_ VGND VGND VPWR VPWR
+ _0666_ sky130_fd_sc_hd__a22oi_4
XFILLER_172_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2675_ i_mem_slice_stage.mem_state_o\[53\] i_mem_slice_stage.mem_state_o\[14\] _0453_
+ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__mux2_1
XFILLER_160_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4414_ _2120_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
XFILLER_160_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4345_ _2065_ _2066_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__and2b_1
XFILLER_141_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4276_ _2017_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_86_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3227_ _0422_ _1058_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__or2_1
XFILLER_67_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3158_ _0344_ _0470_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__a21oi_1
XFILLER_39_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3089_ _0992_ _0997_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a21o_1
XFILLER_70_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_163_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_2553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2460_ _0408_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__and2b_1
XFILLER_5_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2391_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__buf_8
XFILLER_123_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4130_ net60 _1931_ _1942_ net64 _1840_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__o221a_1
XFILLER_110_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4061_ _1871_ _1876_ _1878_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__or3b_1
XFILLER_49_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_110_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3012_ i_exec_stage.data_fwd_o\[12\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0924_
+ sky130_fd_sc_hd__or4_2
XFILLER_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4963_ clknet_leaf_3_clk_i _0143_ net285 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3914_ _0864_ _1774_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__nor2_1
X_4894_ clknet_leaf_12_clk_i _0074_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[132\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_149_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_60_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3845_ _0430_ _1723_ _1724_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__or3_1
XFILLER_20_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3776_ _1657_ _0779_ _1638_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__or3_1
X_2727_ i_mem_slice_stage.mem_state_o\[49\] i_mem_slice_stage.mem_state_o\[10\] _0453_
+ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__mux2_1
XFILLER_133_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2658_ _0525_ _0587_ _0572_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__a21o_1
XFILLER_121_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2589_ i_mem_slice_stage.mem_state_o\[68\] i_mem_slice_stage.mem_state_o\[29\] _0453_
+ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__mux2_2
XFILLER_99_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4328_ net226 _1840_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__or2_1
X_4259_ _2008_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_358 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_170_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_155_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3630_ _0707_ _1519_ _1520_ _0709_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__o211a_1
X_3561_ _0858_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__inv_2
XFILLER_115_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2512_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__or3_1
X_5300_ clknet_leaf_24_clk_i _0299_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[34\]
+ sky130_fd_sc_hd__dfxtp_1
X_3492_ _0421_ _1356_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__or2_1
XFILLER_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2443_ i_decode_stage.decode_state_o\[41\] _0339_ _0392_ _2333_ VGND VGND VPWR VPWR
+ _0393_ sky130_fd_sc_hd__a211o_1
X_5231_ clknet_leaf_16_clk_i _0230_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[29\]
+ sky130_fd_sc_hd__dfrtp_1
X_5162_ clknet_leaf_10_clk_i net376 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[69\]
+ sky130_fd_sc_hd__dfrtp_1
X_2374_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__buf_4
X_4113_ net59 net56 net34 net45 VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__and4bb_4
XFILLER_111_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5093_ clknet_leaf_16_clk_i i_decode_stage.decode_state_o\[37\] net291 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[68\] sky130_fd_sc_hd__dfrtp_1
XFILLER_68_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4044_ _0676_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__inv_2
XFILLER_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_92_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4946_ clknet_leaf_0_clk_i _0126_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4877_ clknet_leaf_15_clk_i _0057_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[61\]
+ sky130_fd_sc_hd__dfrtp_1
X_3828_ _1009_ _1707_ _0773_ _0782_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__or4_1
XFILLER_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_165_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_165_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3759_ _0540_ _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__nor2_1
XFILLER_106_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput250 net250 VGND VGND VPWR VPWR rf_wr_data_o[17] sky130_fd_sc_hd__clkbuf_4
Xoutput261 net261 VGND VGND VPWR VPWR rf_wr_data_o[27] sky130_fd_sc_hd__buf_2
XFILLER_161_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput272 net272 VGND VGND VPWR VPWR rf_wr_data_o[8] sky130_fd_sc_hd__buf_2
XFILLER_101_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_30_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_30_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_71_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_130_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_155_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4800_ _2322_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
XFILLER_34_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2992_ _0876_ _0902_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4731_ net220 i_decode_stage.fetch_state_i\[60\] _1927_ VGND VGND VPWR VPWR _2288_
+ sky130_fd_sc_hd__mux2_1
XTAP_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_174_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4662_ _2258_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3613_ _1045_ _1313_ _0448_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__o21a_1
XFILLER_174_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4593_ _2224_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
X_3544_ _0424_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__nand2_1
XFILLER_143_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3475_ _0660_ _1284_ _1372_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__o21ai_1
XFILLER_103_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2426_ i_decode_stage.reg_meta_o\[81\] net274 _0359_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__nand3_4
X_5214_ clknet_leaf_27_clk_i _0213_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_130_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5145_ clknet_leaf_5_clk_i net347 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[52\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2357_ _0307_ _0308_ _0309_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand4_4
XFILLER_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_84_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5076_ clknet_leaf_28_clk_i i_decode_stage.decode_state_o\[20\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[51\] sky130_fd_sc_hd__dfrtp_1
X_4027_ _0490_ _0978_ _0986_ _0505_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__a22o_1
XFILLER_84_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_37_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4929_ clknet_leaf_20_clk_i _0109_ net288 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dfrtp_4
XFILLER_138_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_161_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_89 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_73 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_56_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_436 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_261 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_156_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_171_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3260_ _0889_ _0892_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__nor2_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3191_ _0709_ _1045_ _1049_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__a211o_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_19_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2975_ _0589_ _0691_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__xnor2_1
X_4714_ _2279_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
XFILLER_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_30_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4645_ i_decode_stage.fetch_state_i\[12\] _2079_ _2234_ VGND VGND VPWR VPWR _2250_
+ sky130_fd_sc_hd__mux2_1
XFILLER_146_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4576_ i_decode_stage.reg_meta_o\[59\] net73 _2207_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__mux2_1
X_3527_ _0593_ _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__or2_1
XFILLER_143_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3458_ _1295_ _1356_ _0421_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__mux2_1
XFILLER_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3389_ _1129_ _1276_ _1278_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__o31a_1
XFILLER_85_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2409_ _0359_ _0360_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and3_1
X_5128_ clknet_leaf_10_clk_i i_mem_slice_stage.pre_data\[31\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_111_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_85_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5059_ clknet_leaf_5_clk_i net149 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[34\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_38_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_166_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold71 i_decode_stage.decode_state_o\[32\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_29_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold60 i_exec_stage.reg_meta_o\[0\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_152_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_48_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_157_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2760_ i_mem_slice_stage.mem_state_o\[76\] _0328_ _0679_ _0330_ VGND VGND VPWR VPWR
+ net269 sky130_fd_sc_hd__a22o_1
XFILLER_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2691_ i_mem_slice_stage.mem_state_o\[55\] i_mem_slice_stage.mem_state_o\[16\] _0453_
+ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__mux2_1
XFILLER_172_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4430_ _2042_ _2133_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__or2_1
XFILLER_6_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_98_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4361_ net203 _2075_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__xor2_1
X_3312_ _0418_ _0416_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__and2_2
X_4292_ _0631_ _1928_ _2029_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__a21oi_1
XFILLER_140_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3243_ i_decode_stage.decode_state_o\[237\] _0416_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__and2_2
XFILLER_100_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3174_ _1079_ _1085_ _0523_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__mux2_1
XFILLER_67_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2958_ i_exec_stage.data_fwd_o\[8\] _0322_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__nor2_1
XFILLER_22_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2889_ i_decode_stage.decode_state_o\[61\] _0731_ _0733_ VGND VGND VPWR VPWR _0804_
+ sky130_fd_sc_hd__a21oi_1
X_4628_ _2241_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
XFILLER_151_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_228 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4559_ _0722_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__clkbuf_16
XFILLER_1_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_131_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_167_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_154_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_163_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3930_ _0444_ _0812_ _0601_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__mux2_1
XFILLER_17_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_51_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3861_ _1198_ _0736_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__a21o_1
XFILLER_20_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3792_ _1007_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__inv_2
XFILLER_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2812_ _2336_ _2341_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nand2_8
XFILLER_164_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2743_ i_exec_stage.data_fwd_o\[8\] _0664_ _0460_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__mux2_2
XFILLER_173_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_117_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2674_ _0450_ _0600_ _0602_ _0492_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_133_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4413_ net215 _2119_ _2012_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__mux2_1
XFILLER_125_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4344_ net228 net229 _2055_ net230 VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__a31o_1
XFILLER_101_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_113_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4275_ net57 i_decode_stage.decode_state_o\[134\] _1967_ VGND VGND VPWR VPWR _2017_
+ sky130_fd_sc_hd__mux2_1
XFILLER_86_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3226_ _1129_ _1131_ _0594_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__o21ai_1
XFILLER_86_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3157_ _0465_ _0563_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__and2_1
XFILLER_67_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3088_ _0983_ _0998_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a21o_1
XFILLER_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_22_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_159_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_41_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_139_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_729 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_174_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2390_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__buf_8
XFILLER_96_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_150_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4060_ _0615_ _1785_ _0908_ _0671_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__o221a_1
XFILLER_110_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3011_ _0324_ _0326_ i_decode_stage.reg_meta_o\[17\] VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__o21a_1
XFILLER_49_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4962_ clknet_leaf_1_clk_i _0142_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_51_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4893_ clknet_leaf_12_clk_i _0073_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[131\]
+ sky130_fd_sc_hd__dfrtp_4
X_3913_ _0726_ _0835_ _0836_ _0837_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__a31oi_4
XFILLER_149_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3844_ _1016_ _1004_ _1012_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__and3_1
XFILLER_60_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_164_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_681 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3775_ _0779_ _1638_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__o21ai_1
XFILLER_145_320 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_545 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2726_ _0346_ i_decode_stage.decode_state_o\[133\] _0347_ _0649_ VGND VGND VPWR VPWR
+ _0650_ sky130_fd_sc_hd__a22oi_4
XFILLER_173_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2657_ _0421_ _0586_ _0539_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__o21a_1
XFILLER_118_589 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_160_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2588_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__buf_2
XFILLER_160_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_86_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4327_ _2051_ _2052_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__nor2_1
X_4258_ net37 i_decode_stage.decode_state_o\[0\] _1967_ VGND VGND VPWR VPWR _2008_
+ sky130_fd_sc_hd__mux2_1
X_3209_ _0540_ _1062_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__or2_1
XFILLER_28_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_38 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4189_ i_decode_stage.fetch_state_i\[30\] i_decode_stage.decode_state_o\[38\] _1967_
+ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__mux2_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_169_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_146_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3560_ _1450_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__nor2_1
XFILLER_127_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_155_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2511_ net257 i_decode_stage.reg_meta_o\[67\] _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
XFILLER_170_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3491_ _0344_ _0633_ _0657_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__a21o_1
XFILLER_115_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5230_ clknet_leaf_17_clk_i _0229_ net292 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[28\]
+ sky130_fd_sc_hd__dfrtp_1
X_2442_ i_decode_stage.decode_state_o\[125\] _0337_ _0338_ i_decode_stage.decode_state_o\[137\]
+ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a22o_1
XFILLER_5_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5161_ clknet_leaf_11_clk_i net349 net296 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[68\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_111_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2373_ i_mem_slice_stage.mem_state_o\[36\] i_mem_slice_stage.mem_state_o\[37\] VGND
+ VGND VPWR VPWR _0327_ sky130_fd_sc_hd__and2_1
XFILLER_111_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4112_ _1928_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__clkbuf_8
X_5092_ clknet_leaf_18_clk_i net412 net291 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_68_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4043_ _1857_ _1858_ _1859_ _1860_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__a211oi_1
XFILLER_56_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_148 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4945_ clknet_leaf_1_clk_i _0125_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_52_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4876_ clknet_leaf_16_clk_i _0056_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[60\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_821 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3827_ _0764_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__inv_1
X_3758_ _0344_ _0470_ _1050_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__a21oi_1
XFILLER_152_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2709_ i_mem_slice_stage.mem_state_o\[51\] i_mem_slice_stage.mem_state_o\[12\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__mux2_1
XFILLER_165_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3689_ _0413_ _0815_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__nor2_1
XFILLER_161_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_160_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput262 net262 VGND VGND VPWR VPWR rf_wr_data_o[28] sky130_fd_sc_hd__buf_2
Xoutput240 net240 VGND VGND VPWR VPWR rf_port2_reg_o[3] sky130_fd_sc_hd__buf_2
Xoutput251 net251 VGND VGND VPWR VPWR rf_wr_data_o[18] sky130_fd_sc_hd__buf_2
XFILLER_121_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_114_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput273 net273 VGND VGND VPWR VPWR rf_wr_data_o[9] sky130_fd_sc_hd__buf_2
XFILLER_160_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_59_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_83_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_169_765 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_24_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_171_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_74_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2991_ _0666_ _0875_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__and2b_1
X_4730_ _2287_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
XTAP_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4661_ i_decode_stage.fetch_state_i\[20\] _2107_ _2234_ VGND VGND VPWR VPWR _2258_
+ sky130_fd_sc_hd__mux2_1
X_3612_ _1199_ _1502_ _1503_ _0973_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__o31a_1
XFILLER_116_813 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4592_ i_decode_stage.reg_meta_o\[67\] net82 _2207_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__mux2_1
XFILLER_127_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3543_ _0417_ _0603_ _0841_ _0413_ _1437_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__o221a_1
XFILLER_143_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3474_ _0525_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__or2_1
XFILLER_115_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_529 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_88_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5213_ clknet_leaf_28_clk_i _0212_ net281 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[11\]
+ sky130_fd_sc_hd__dfrtp_1
X_2425_ _0365_ _0366_ _0367_ _0372_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__nand4_4
XFILLER_130_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5144_ clknet_leaf_6_clk_i net341 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[51\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2356_ i_exec_stage.data_fwd_o\[35\] i_decode_stage.decode_state_o\[126\] VGND VGND
+ VPWR VPWR _0310_ sky130_fd_sc_hd__or2b_1
XFILLER_28_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5075_ clknet_leaf_28_clk_i i_decode_stage.decode_state_o\[19\] net281 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[50\] sky130_fd_sc_hd__dfrtp_1
X_4026_ _0510_ _0961_ _0969_ _0620_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__a22o_1
XFILLER_84_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_129 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_65_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4928_ clknet_leaf_20_clk_i _0108_ net288 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dfrtp_4
XFILLER_166_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4859_ clknet_leaf_21_clk_i _0039_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[43\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_153_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_673 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_161_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_573 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_171_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_124_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3190_ _0709_ _1073_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__o21a_1
XFILLER_79_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2974_ _0884_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nor2_1
XFILLER_148_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4713_ net210 i_decode_stage.fetch_state_i\[51\] _1927_ VGND VGND VPWR VPWR _2279_
+ sky130_fd_sc_hd__mux2_1
XFILLER_148_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4644_ _2249_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_135_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4575_ _2215_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_3526_ _1065_ _1421_ _1396_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__mux2_1
XFILLER_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_143_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3457_ _0672_ _0650_ _0344_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__mux2_1
XFILLER_103_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_17 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3388_ _0448_ _1280_ _1286_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__or4_1
XFILLER_69_251 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2408_ net279 i_decode_stage.decode_state_o\[123\] VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__or2b_1
X_5127_ clknet_leaf_10_clk_i i_mem_slice_stage.pre_data\[30\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[30\] sky130_fd_sc_hd__dfrtp_1
XFILLER_84_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_413 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5058_ clknet_leaf_6_clk_i net148 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[33\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_85_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4009_ net14 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[21\] sky130_fd_sc_hd__a21o_1
XFILLER_84_287 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_26_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_13_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_162_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_121_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold50 i_exec_stage.exec_state_o\[25\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_76_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold61 i_exec_stage.exec_state_o\[6\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold72 i_exec_stage.exec_state_o\[55\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_48_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xcore_330 VGND VGND VPWR VPWR core_330/HI imem_wdata_o[26] sky130_fd_sc_hd__conb_1
XFILLER_16_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2690_ _0451_ _0615_ _0616_ _0492_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_172_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_172_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4360_ net133 _2042_ _2045_ _2077_ _2078_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__a221o_1
XFILLER_125_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3311_ _0590_ _1204_ _1208_ _1211_ _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__a311o_1
XFILLER_140_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4291_ _0722_ _2019_ _2028_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__and3_1
XFILLER_4_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3242_ _0525_ _0703_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__nand2_1
XFILLER_112_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3173_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__inv_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2957_ i_decode_stage.reg_meta_o\[13\] _0727_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__nand2_1
XFILLER_50_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2888_ i_exec_stage.data_fwd_o\[22\] _0726_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__o21ai_4
XFILLER_148_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4627_ i_decode_stage.fetch_state_i\[3\] _2049_ _2234_ VGND VGND VPWR VPWR _2241_
+ sky130_fd_sc_hd__mux2_1
XFILLER_104_613 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4558_ _2206_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
XFILLER_173_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3509_ _0834_ _1403_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__nor2_1
XFILLER_104_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4489_ _2171_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_357 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_66_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_158_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_167_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_154_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3860_ _0448_ _1735_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__o21ai_1
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3791_ _1158_ _1670_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__or3b_1
X_2811_ _0322_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__buf_12
XFILLER_32_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2742_ net271 i_decode_stage.reg_meta_o\[51\] _0457_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__mux2_1
XFILLER_173_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_157_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_172_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2673_ _0601_ _0493_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
X_4412_ net145 _2118_ _1924_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__mux2_1
XFILLER_172_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_126_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4343_ net228 net229 net230 _2055_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__and4_1
X_4274_ _2016_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_141_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3225_ _0590_ _1130_ _1126_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__o21a_1
XFILLER_67_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3156_ _0343_ _0568_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3087_ _0495_ _0980_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__and2b_1
XFILLER_82_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_27_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_149_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3989_ _1810_ _1831_ _1830_ _1814_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__a22oi_4
XFILLER_164_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_109_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_77_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_319 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_14_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_167_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_155_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_9_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_158_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_170_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_154_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_108_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_123_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_96_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_49_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3010_ _2336_ _2341_ net244 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__and3_1
XFILLER_49_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_36_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4961_ clknet_leaf_1_clk_i _0141_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4892_ clknet_leaf_12_clk_i _0072_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[130\]
+ sky130_fd_sc_hd__dfrtp_4
X_3912_ _1780_ _1774_ _1781_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__a21o_1
XFILLER_149_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3843_ _1004_ _1012_ _1016_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_158_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_513 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3774_ _0773_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__inv_2
XFILLER_20_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_173_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_157_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_145_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_557 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2725_ _0358_ _0643_ _0646_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__o31ai_4
XFILLER_173_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2656_ _0345_ _0545_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nand2_1
XFILLER_172_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2587_ i_decode_stage.decode_state_o\[125\] i_decode_stage.decode_state_o\[41\] net178
+ i_decode_stage.decode_state_o\[137\] i_decode_stage.decode_state_o\[233\] _0338_
+ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__mux4_2
XFILLER_99_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4326_ net222 net225 net226 VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__a21oi_1
XFILLER_75_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4257_ _2007_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
XFILLER_170_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4188_ _1972_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_28_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3208_ _0645_ VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__inv_2
X_3139_ _0344_ _0484_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a21oi_1
XFILLER_103_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_82_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_168_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_168_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_629 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_12_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_151_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_105_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_104_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_2_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_120_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_144_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_46_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_2352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_82 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_174_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_174_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_128_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_155_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_127_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_505 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3490_ _0952_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__xnor2_1
X_2510_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__buf_6
XFILLER_154_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2441_ _0391_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__inv_2
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_170_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5160_ clknet_leaf_8_clk_i net339 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
X_2372_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__buf_4
X_4111_ _1927_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__buf_6
X_5091_ clknet_leaf_16_clk_i i_decode_stage.decode_state_o\[35\] net291 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[66\] sky130_fd_sc_hd__dfrtp_1
XFILLER_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4042_ _0444_ _0693_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__and2_1
XFILLER_49_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_64_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4944_ clknet_leaf_17_clk_i _0124_ net292 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[140\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_52_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_33_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4875_ clknet_leaf_22_clk_i _0055_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[59\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_20_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3826_ _1706_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_165_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_119_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3757_ _0825_ _1003_ _0782_ _0430_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__a31o_1
XFILLER_20_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_825 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_118_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2708_ _0451_ _0630_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__o21ai_4
XFILLER_133_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3688_ _1479_ _1575_ _0448_ _1219_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_118_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_160_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2639_ _0558_ _0570_ _0394_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__mux2_1
Xoutput230 net230 VGND VGND VPWR VPWR imem_addr_o[8] sky130_fd_sc_hd__buf_2
Xoutput241 net241 VGND VGND VPWR VPWR rf_port2_reg_o[4] sky130_fd_sc_hd__buf_2
Xoutput252 net252 VGND VGND VPWR VPWR rf_wr_data_o[19] sky130_fd_sc_hd__buf_2
XFILLER_160_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput274 net274 VGND VGND VPWR VPWR rf_wr_en_o sky130_fd_sc_hd__clkbuf_4
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput263 net263 VGND VGND VPWR VPWR rf_wr_data_o[29] sky130_fd_sc_hd__buf_2
XFILLER_141_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4309_ _1928_ _2028_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__nor2_1
XFILLER_59_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5289_ clknet_leaf_6_clk_i _0288_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_75_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_15_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_168_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_168_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_23_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_137_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_155_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_311 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2990_ _0881_ _0900_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a21o_1
XFILLER_34_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4660_ _2257_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
XFILLER_147_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3611_ _0417_ _0622_ _0972_ _1198_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_162_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4591_ _2223_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3542_ _1198_ _0841_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__nand2_1
XFILLER_142_121 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3473_ _1327_ _1370_ _0421_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__mux2_1
XFILLER_89_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_142_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5212_ clknet_leaf_27_clk_i _0211_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_2424_ _0360_ _0361_ _0364_ _0371_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__nand4_4
X_5143_ clknet_leaf_5_clk_i net348 net296 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[50\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_97_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2355_ i_exec_stage.data_fwd_o\[34\] i_decode_stage.decode_state_o\[125\] VGND VGND
+ VPWR VPWR _0309_ sky130_fd_sc_hd__or2b_1
XFILLER_111_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_111_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_97_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5074_ clknet_leaf_28_clk_i i_decode_stage.decode_state_o\[18\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[49\] sky130_fd_sc_hd__dfrtp_1
X_4025_ _0510_ _0961_ _0986_ _0505_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__o22ai_1
XFILLER_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_171 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4927_ clknet_leaf_20_clk_i _0107_ net288 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dfrtp_4
XFILLER_166_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_100_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4858_ clknet_leaf_22_clk_i _0038_ net286 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[42\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3809_ _0762_ _1670_ _0756_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__o21ai_1
XFILLER_21_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_165_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_641 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4789_ i_exec_stage.data_fwd_o\[25\] net146 _1838_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__mux2_1
XFILLER_119_685 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_106_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_161_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_161_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_134_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_657 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_47_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_541 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_71_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_169_585 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_8_713 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_757 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_171_249 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_39_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_78_274 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_93_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_61_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2973_ _0447_ _0695_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__nor2_1
XFILLER_50_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_725 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_147_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4712_ _2278_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
XFILLER_148_769 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4643_ i_decode_stage.fetch_state_i\[11\] _2077_ _2234_ VGND VGND VPWR VPWR _2249_
+ sky130_fd_sc_hd__mux2_1
XFILLER_147_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4574_ i_decode_stage.reg_meta_o\[58\] net72 _2207_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__mux2_1
XFILLER_143_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3525_ _0545_ _1216_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__nand2_1
XFILLER_171_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_115_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3456_ _0650_ _0919_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__nand2_1
XFILLER_103_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3387_ _1287_ _1288_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__nor2_1
XFILLER_97_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2407_ i_decode_stage.decode_state_o\[121\] net277 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__or2b_1
X_5126_ clknet_leaf_11_clk_i i_mem_slice_stage.pre_data\[29\] net296 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[29\] sky130_fd_sc_hd__dfrtp_1
XFILLER_69_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_57_425 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5057_ clknet_leaf_5_clk_i net147 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[32\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_29_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_2918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4008_ net13 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[20\] sky130_fd_sc_hd__a21o_1
XTAP_2929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_517 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_166_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_21_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_153_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_5_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_161_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_122_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_20_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_136_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_76_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold40 i_exec_stage.exec_state_o\[26\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_75_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold51 i_exec_stage.exec_state_o\[40\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_75_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold62 i_exec_stage.exec_state_o\[44\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold73 i_exec_stage.exec_state_o\[56\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkdlybuf4s50_1
XFILLER_48_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_320 VGND VGND VPWR VPWR core_320/HI imem_wdata_o[16] sky130_fd_sc_hd__conb_1
XFILLER_16_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_331 VGND VGND VPWR VPWR core_331/HI imem_wdata_o[27] sky130_fd_sc_hd__conb_1
XFILLER_71_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_16_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_169_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_129_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_172_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3310_ _0886_ _0896_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__a21oi_1
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_125_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_112_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4290_ _1930_ _1938_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__nand2_1
XFILLER_4_793 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_3_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_140_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3241_ _1144_ _1146_ _0892_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__o21ai_1
XFILLER_112_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_79_561 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3172_ _1081_ _1083_ _0527_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__mux2_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_81_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_34_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_90_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_62_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_35_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_50_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_148_533 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2956_ _0441_ net271 VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__nand2_1
X_2887_ i_decode_stage.reg_meta_o\[27\] _0727_ _0386_ _0801_ VGND VGND VPWR VPWR _0802_
+ sky130_fd_sc_hd__a211o_1
XFILLER_163_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4626_ i_decode_stage.fetch_state_i\[2\] _1840_ _2043_ VGND VGND VPWR VPWR _0203_
+ sky130_fd_sc_hd__o21a_1
XFILLER_151_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4557_ i_decode_stage.reg_meta_o\[50\] net95 _2179_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__mux2_1
X_3508_ _0834_ _1403_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__nand2_1
XFILLER_104_625 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_103_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4488_ i_decode_stage.reg_meta_o\[16\] net100 _2012_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__mux2_1
X_3439_ _1305_ _1267_ _1338_ _1308_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__o31a_1
XFILLER_104_669 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_89_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_58_701 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5109_ clknet_leaf_9_clk_i i_mem_slice_stage.pre_data\[12\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_597 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_2748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_2759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_159_809 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_53_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_40_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_166_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_154_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_154_569 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_74 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_135_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_107_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_741 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_163_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_1_785 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput130 rf_rs2_i[9] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_1
XFILLER_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_737 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_653 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_72_781 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_17_697 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_32_601 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_645 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2810_ _0532_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__inv_2
X_3790_ _1657_ _1638_ _1671_ _0764_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__a211o_1
XFILLER_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2741_ i_mem_slice_stage.mem_state_o\[78\] _0452_ _0663_ _0455_ VGND VGND VPWR VPWR
+ net271 sky130_fd_sc_hd__a22o_1
XFILLER_157_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_172_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_133_709 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2672_ i_decode_stage.decode_state_o\[117\] VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__buf_6
X_4411_ _2116_ _2117_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__nor2_1
XFILLER_172_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_132_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4342_ net159 _2047_ _2048_ _2063_ _2064_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__o221a_1
X_4273_ i_decode_stage.decode_state_o\[133\] net55 _2012_ VGND VGND VPWR VPWR _2016_
+ sky130_fd_sc_hd__mux2_1
XFILLER_141_753 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_141_797 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3224_ _0662_ _1115_ _1119_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a21oi_1
XFILLER_101_617 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
.ends
